MACRO lna
  UNITS
    DISTANCE MICRONS 1;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN lna 0 0 ;
  SIZE 897145 BY 352079 ;
    OBS
      LAYER M1 ;
        RECT 264352 106445 264442 106685 ;
        RECT 264072 106445 264162 106685 ;
        RECT 263792 106445 263882 106685 ;
        RECT 263512 106445 263602 106685 ;
        RECT 264632 106445 264722 106685 ;
        RECT 263667 106170 264567 106350 ;
        RECT 263467 106445 263647 106685 ;
        RECT 264027 106445 264207 106685 ;
        RECT 264587 106445 264767 106685 ;
        RECT 263747 106445 263927 106685 ;
        RECT 264307 106445 264487 106685 ;
        RECT 265022 106665 265302 107125 ;
        RECT 262932 106665 263212 107125 ;
        RECT 265022 106005 265302 106465 ;
        RECT 262932 106005 263212 106465 ;
        RECT 262932 107125 265302 107335 ;
        RECT 262932 105795 265302 106005 ;
        RECT 265022 106445 265302 106685 ;
        RECT 262932 106445 263212 106685 ;
        RECT 263667 106215 264567 106305 ;
        RECT 262932 106445 263212 106685 ;
        RECT 265022 106445 265302 106685 ;
        RECT 247526 125195 248566 125375 ;
        RECT 247526 118475 248566 118655 ;
        RECT 247526 124915 248566 125095 ;
        RECT 247526 124635 248566 124815 ;
        RECT 247526 124355 248566 124535 ;
        RECT 247526 124075 248566 124255 ;
        RECT 247526 123795 248566 123975 ;
        RECT 247526 123515 248566 123695 ;
        RECT 247526 123235 248566 123415 ;
        RECT 247526 122955 248566 123135 ;
        RECT 247526 122675 248566 122855 ;
        RECT 247526 122395 248566 122575 ;
        RECT 247526 122115 248566 122295 ;
        RECT 247526 121835 248566 122015 ;
        RECT 247526 121555 248566 121735 ;
        RECT 247526 121275 248566 121455 ;
        RECT 247526 120995 248566 121175 ;
        RECT 247526 120715 248566 120895 ;
        RECT 247526 120435 248566 120615 ;
        RECT 247526 120155 248566 120335 ;
        RECT 247526 119875 248566 120055 ;
        RECT 247526 119595 248566 119775 ;
        RECT 247526 119315 248566 119495 ;
        RECT 247526 119035 248566 119215 ;
        RECT 247526 118755 248566 118935 ;
        RECT 248666 118675 248846 125175 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 245836 124915 246876 125095 ;
        RECT 245836 124635 246876 124815 ;
        RECT 245836 124355 246876 124535 ;
        RECT 245836 124075 246876 124255 ;
        RECT 245836 123795 246876 123975 ;
        RECT 245836 123515 246876 123695 ;
        RECT 245836 123235 246876 123415 ;
        RECT 245836 122955 246876 123135 ;
        RECT 245836 122675 246876 122855 ;
        RECT 245836 122395 246876 122575 ;
        RECT 245836 122115 246876 122295 ;
        RECT 245836 121835 246876 122015 ;
        RECT 245836 121555 246876 121735 ;
        RECT 245836 121275 246876 121455 ;
        RECT 245836 120995 246876 121175 ;
        RECT 245836 120715 246876 120895 ;
        RECT 245836 120435 246876 120615 ;
        RECT 245836 120155 246876 120335 ;
        RECT 245836 119875 246876 120055 ;
        RECT 245836 119595 246876 119775 ;
        RECT 245836 119315 246876 119495 ;
        RECT 245836 119035 246876 119215 ;
        RECT 245836 118755 246876 118935 ;
        RECT 246976 118675 247156 125175 ;
        RECT 245556 118675 245736 125175 ;
        RECT 245186 118010 249216 125840 ;
        RECT 104080 66444 215042 177406 ;
        RECT 280424 56223 411826 187625 ;
        RECT 226296 131230 269796 219230 ;
        RECT 265200 109070 265290 116440 ;
        RECT 240210 109070 240300 116440 ;
        RECT 266755 102163 270685 102253 ;
        RECT 266755 118403 270685 118493 ;
        RECT 235140 111395 235230 115885 ;
        RECT 238660 111395 238750 115885 ;
        RECT 268676 119959 268766 123889 ;
        RECT 252436 119959 252526 123889 ;
      LAYER M2 ;
        RECT 262932 107335 265302 107835 ;
        RECT 263747 106685 263927 107605 ;
        RECT 264307 106685 264487 107605 ;
        RECT 263667 106170 264567 106350 ;
        RECT 263667 106170 264567 106350 ;
        RECT 263467 106420 263647 106710 ;
        RECT 264027 106420 264207 106710 ;
        RECT 264587 106420 264767 106710 ;
        RECT 263467 106420 263647 106710 ;
        RECT 264027 106420 264207 106710 ;
        RECT 264587 106420 264767 106710 ;
        RECT 263747 106445 263927 106685 ;
        RECT 264307 106445 264487 106685 ;
        RECT 265022 106445 265302 106685 ;
        RECT 262932 106445 263212 106685 ;
        RECT 265022 106445 265302 106685 ;
        RECT 262932 106445 263212 106685 ;
        RECT 247526 125195 248566 125375 ;
        RECT 247526 118475 248566 118655 ;
        RECT 247526 124915 248566 125095 ;
        RECT 247526 124635 248566 124815 ;
        RECT 247526 124355 248566 124535 ;
        RECT 247526 124075 248566 124255 ;
        RECT 247526 123795 248566 123975 ;
        RECT 247526 123515 248566 123695 ;
        RECT 247526 123235 248566 123415 ;
        RECT 247526 122955 248566 123135 ;
        RECT 247526 122675 248566 122855 ;
        RECT 247526 122395 248566 122575 ;
        RECT 247526 122115 248566 122295 ;
        RECT 247526 121835 248566 122015 ;
        RECT 247526 121555 248566 121735 ;
        RECT 247526 121275 248566 121455 ;
        RECT 247526 120995 248566 121175 ;
        RECT 247526 120715 248566 120895 ;
        RECT 247526 120435 248566 120615 ;
        RECT 247526 120155 248566 120335 ;
        RECT 247526 119875 248566 120055 ;
        RECT 247526 119595 248566 119775 ;
        RECT 247526 119315 248566 119495 ;
        RECT 247526 119035 248566 119215 ;
        RECT 247526 118755 248566 118935 ;
        RECT 248666 118675 248846 125175 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 245836 124915 246876 125095 ;
        RECT 245836 124635 246876 124815 ;
        RECT 245836 124355 246876 124535 ;
        RECT 245836 124075 246876 124255 ;
        RECT 245836 123795 246876 123975 ;
        RECT 245836 123515 246876 123695 ;
        RECT 245836 123235 246876 123415 ;
        RECT 245836 122955 246876 123135 ;
        RECT 245836 122675 246876 122855 ;
        RECT 245836 122395 246876 122575 ;
        RECT 245836 122115 246876 122295 ;
        RECT 245836 121835 246876 122015 ;
        RECT 245836 121555 246876 121735 ;
        RECT 245836 121275 246876 121455 ;
        RECT 245836 120995 246876 121175 ;
        RECT 245836 120715 246876 120895 ;
        RECT 245836 120435 246876 120615 ;
        RECT 245836 120155 246876 120335 ;
        RECT 245836 119875 246876 120055 ;
        RECT 245836 119595 246876 119775 ;
        RECT 245836 119315 246876 119495 ;
        RECT 245836 119035 246876 119215 ;
        RECT 245836 118755 246876 118935 ;
        RECT 246976 118675 247156 125175 ;
        RECT 245556 118675 245736 125175 ;
        RECT 104080 66444 215042 177406 ;
        RECT 280424 56223 411826 187625 ;
      LAYER M3 ;
        RECT 262932 105295 265302 105795 ;
        RECT 263667 105660 264567 106170 ;
        RECT 263667 106170 264567 106350 ;
        RECT 263467 106420 263647 106710 ;
        RECT 264027 106420 264207 106710 ;
        RECT 264587 106420 264767 106710 ;
        RECT 263467 106420 263647 106710 ;
        RECT 264027 106420 264207 106710 ;
        RECT 264587 106420 264767 106710 ;
        RECT 265022 106445 265302 106685 ;
        RECT 262932 106445 263212 106685 ;
        RECT 265022 106445 265302 106685 ;
        RECT 262932 106445 263212 106685 ;
        RECT 247526 125195 248566 125375 ;
        RECT 247526 118475 248566 118655 ;
        RECT 247526 124915 248566 125095 ;
        RECT 247526 124635 248566 124815 ;
        RECT 247526 124355 248566 124535 ;
        RECT 247526 124075 248566 124255 ;
        RECT 247526 123795 248566 123975 ;
        RECT 247526 123515 248566 123695 ;
        RECT 247526 123235 248566 123415 ;
        RECT 247526 122955 248566 123135 ;
        RECT 247526 122675 248566 122855 ;
        RECT 247526 122395 248566 122575 ;
        RECT 247526 122115 248566 122295 ;
        RECT 247526 121835 248566 122015 ;
        RECT 247526 121555 248566 121735 ;
        RECT 247526 121275 248566 121455 ;
        RECT 247526 120995 248566 121175 ;
        RECT 247526 120715 248566 120895 ;
        RECT 247526 120435 248566 120615 ;
        RECT 247526 120155 248566 120335 ;
        RECT 247526 119875 248566 120055 ;
        RECT 247526 119595 248566 119775 ;
        RECT 247526 119315 248566 119495 ;
        RECT 247526 119035 248566 119215 ;
        RECT 247526 118755 248566 118935 ;
        RECT 248666 118675 248846 125175 ;
        RECT 248846 118675 249026 125175 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 245836 124915 246876 125095 ;
        RECT 245836 124635 246876 124815 ;
        RECT 245836 124355 246876 124535 ;
        RECT 245836 124075 246876 124255 ;
        RECT 245836 123795 246876 123975 ;
        RECT 245836 123515 246876 123695 ;
        RECT 245836 123235 246876 123415 ;
        RECT 245836 122955 246876 123135 ;
        RECT 245836 122675 246876 122855 ;
        RECT 245836 122395 246876 122575 ;
        RECT 245836 122115 246876 122295 ;
        RECT 245836 121835 246876 122015 ;
        RECT 245836 121555 246876 121735 ;
        RECT 245836 121275 246876 121455 ;
        RECT 245836 120995 246876 121175 ;
        RECT 245836 120715 246876 120895 ;
        RECT 245836 120435 246876 120615 ;
        RECT 245836 120155 246876 120335 ;
        RECT 245836 119875 246876 120055 ;
        RECT 245836 119595 246876 119775 ;
        RECT 245836 119315 246876 119495 ;
        RECT 245836 119035 246876 119215 ;
        RECT 245836 118755 246876 118935 ;
        RECT 246976 118675 247156 125175 ;
        RECT 246976 118175 247156 118675 ;
        RECT 245556 118675 245736 125175 ;
        RECT 245556 118175 245736 118675 ;
        RECT 245556 117675 247156 118175 ;
        RECT 104080 66444 215042 177406 ;
        RECT 280424 56223 411826 187625 ;
      LAYER M4 ;
        RECT 263037 106445 265032 106685 ;
        RECT 263467 106445 263647 106685 ;
        RECT 264027 106445 264207 106685 ;
        RECT 264587 106445 264767 106685 ;
        RECT 265022 106445 265302 106685 ;
        RECT 262932 106445 263212 106685 ;
        RECT 247526 125195 248566 125375 ;
        RECT 247526 118475 248566 118655 ;
        RECT 246876 124915 247526 125095 ;
        RECT 246876 124915 247526 125095 ;
        RECT 246876 124915 247526 125095 ;
        RECT 246876 124915 247526 125095 ;
        RECT 247526 124915 248566 125095 ;
        RECT 246876 124915 247526 125095 ;
        RECT 247526 124635 248566 124815 ;
        RECT 246876 124355 247526 124535 ;
        RECT 246876 124355 247526 124535 ;
        RECT 246876 124355 247526 124535 ;
        RECT 246876 124355 247526 124535 ;
        RECT 247526 124355 248566 124535 ;
        RECT 246876 124355 247526 124535 ;
        RECT 247526 124075 248566 124255 ;
        RECT 246876 123795 247526 123975 ;
        RECT 246876 123795 247526 123975 ;
        RECT 246876 123795 247526 123975 ;
        RECT 246876 123795 247526 123975 ;
        RECT 247526 123795 248566 123975 ;
        RECT 246876 123795 247526 123975 ;
        RECT 247526 123515 248566 123695 ;
        RECT 246876 123235 247526 123415 ;
        RECT 246876 123235 247526 123415 ;
        RECT 246876 123235 247526 123415 ;
        RECT 246876 123235 247526 123415 ;
        RECT 247526 123235 248566 123415 ;
        RECT 246876 123235 247526 123415 ;
        RECT 247526 122955 248566 123135 ;
        RECT 246876 122675 247526 122855 ;
        RECT 246876 122675 247526 122855 ;
        RECT 246876 122675 247526 122855 ;
        RECT 246876 122675 247526 122855 ;
        RECT 247526 122675 248566 122855 ;
        RECT 246876 122675 247526 122855 ;
        RECT 247526 122395 248566 122575 ;
        RECT 246876 122115 247526 122295 ;
        RECT 246876 122115 247526 122295 ;
        RECT 246876 122115 247526 122295 ;
        RECT 246876 122115 247526 122295 ;
        RECT 247526 122115 248566 122295 ;
        RECT 246876 122115 247526 122295 ;
        RECT 247526 121835 248566 122015 ;
        RECT 246876 121555 247526 121735 ;
        RECT 246876 121555 247526 121735 ;
        RECT 246876 121555 247526 121735 ;
        RECT 246876 121555 247526 121735 ;
        RECT 247526 121555 248566 121735 ;
        RECT 246876 121555 247526 121735 ;
        RECT 247526 121275 248566 121455 ;
        RECT 246876 120995 247526 121175 ;
        RECT 246876 120995 247526 121175 ;
        RECT 246876 120995 247526 121175 ;
        RECT 246876 120995 247526 121175 ;
        RECT 247526 120995 248566 121175 ;
        RECT 246876 120995 247526 121175 ;
        RECT 247526 120715 248566 120895 ;
        RECT 246876 120435 247526 120615 ;
        RECT 246876 120435 247526 120615 ;
        RECT 246876 120435 247526 120615 ;
        RECT 246876 120435 247526 120615 ;
        RECT 247526 120435 248566 120615 ;
        RECT 246876 120435 247526 120615 ;
        RECT 247526 120155 248566 120335 ;
        RECT 246876 119875 247526 120055 ;
        RECT 246876 119875 247526 120055 ;
        RECT 246876 119875 247526 120055 ;
        RECT 246876 119875 247526 120055 ;
        RECT 247526 119875 248566 120055 ;
        RECT 246876 119875 247526 120055 ;
        RECT 247526 119595 248566 119775 ;
        RECT 246876 119315 247526 119495 ;
        RECT 246876 119315 247526 119495 ;
        RECT 246876 119315 247526 119495 ;
        RECT 246876 119315 247526 119495 ;
        RECT 247526 119315 248566 119495 ;
        RECT 246876 119315 247526 119495 ;
        RECT 247526 119035 248566 119215 ;
        RECT 246876 118755 247526 118935 ;
        RECT 246876 118755 247526 118935 ;
        RECT 246876 118755 247526 118935 ;
        RECT 246876 118755 247526 118935 ;
        RECT 247526 118755 248566 118935 ;
        RECT 246876 118755 247526 118935 ;
        RECT 248846 118675 249206 125175 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 245836 124915 246876 125095 ;
        RECT 245836 124635 246876 124815 ;
        RECT 245836 124355 246876 124535 ;
        RECT 245836 124075 246876 124255 ;
        RECT 245836 123795 246876 123975 ;
        RECT 245836 123515 246876 123695 ;
        RECT 245836 123235 246876 123415 ;
        RECT 245836 122955 246876 123135 ;
        RECT 245836 122675 246876 122855 ;
        RECT 245836 122395 246876 122575 ;
        RECT 245836 122115 246876 122295 ;
        RECT 245836 121835 246876 122015 ;
        RECT 245836 121555 246876 121735 ;
        RECT 245836 121275 246876 121455 ;
        RECT 245836 120995 246876 121175 ;
        RECT 245836 120715 246876 120895 ;
        RECT 245836 120435 246876 120615 ;
        RECT 245836 120155 246876 120335 ;
        RECT 245836 119875 246876 120055 ;
        RECT 245836 119595 246876 119775 ;
        RECT 245836 119315 246876 119495 ;
        RECT 245836 119035 246876 119215 ;
        RECT 245836 118755 246876 118935 ;
        RECT 104080 66444 215042 177406 ;
        RECT 280424 56223 411826 187625 ;
      LAYER M5 ;
        RECT 247526 125195 248566 125375 ;
        RECT 247526 118475 248566 118655 ;
        RECT 246876 124915 247526 125095 ;
        RECT 246876 124915 247526 125095 ;
        RECT 246876 124915 247526 125095 ;
        RECT 246876 124915 247526 125095 ;
        RECT 246876 124915 247526 125095 ;
        RECT 247526 124915 248566 125095 ;
        RECT 247526 124635 248566 124815 ;
        RECT 246876 124355 247526 124535 ;
        RECT 246876 124355 247526 124535 ;
        RECT 246876 124355 247526 124535 ;
        RECT 246876 124355 247526 124535 ;
        RECT 246876 124355 247526 124535 ;
        RECT 247526 124355 248566 124535 ;
        RECT 247526 124075 248566 124255 ;
        RECT 246876 123795 247526 123975 ;
        RECT 246876 123795 247526 123975 ;
        RECT 246876 123795 247526 123975 ;
        RECT 246876 123795 247526 123975 ;
        RECT 246876 123795 247526 123975 ;
        RECT 247526 123795 248566 123975 ;
        RECT 247526 123515 248566 123695 ;
        RECT 246876 123235 247526 123415 ;
        RECT 246876 123235 247526 123415 ;
        RECT 246876 123235 247526 123415 ;
        RECT 246876 123235 247526 123415 ;
        RECT 246876 123235 247526 123415 ;
        RECT 247526 123235 248566 123415 ;
        RECT 247526 122955 248566 123135 ;
        RECT 246876 122675 247526 122855 ;
        RECT 246876 122675 247526 122855 ;
        RECT 246876 122675 247526 122855 ;
        RECT 246876 122675 247526 122855 ;
        RECT 246876 122675 247526 122855 ;
        RECT 247526 122675 248566 122855 ;
        RECT 247526 122395 248566 122575 ;
        RECT 246876 122115 247526 122295 ;
        RECT 246876 122115 247526 122295 ;
        RECT 246876 122115 247526 122295 ;
        RECT 246876 122115 247526 122295 ;
        RECT 246876 122115 247526 122295 ;
        RECT 247526 122115 248566 122295 ;
        RECT 247526 121835 248566 122015 ;
        RECT 246876 121555 247526 121735 ;
        RECT 246876 121555 247526 121735 ;
        RECT 246876 121555 247526 121735 ;
        RECT 246876 121555 247526 121735 ;
        RECT 246876 121555 247526 121735 ;
        RECT 247526 121555 248566 121735 ;
        RECT 247526 121275 248566 121455 ;
        RECT 246876 120995 247526 121175 ;
        RECT 246876 120995 247526 121175 ;
        RECT 246876 120995 247526 121175 ;
        RECT 246876 120995 247526 121175 ;
        RECT 246876 120995 247526 121175 ;
        RECT 247526 120995 248566 121175 ;
        RECT 247526 120715 248566 120895 ;
        RECT 246876 120435 247526 120615 ;
        RECT 246876 120435 247526 120615 ;
        RECT 246876 120435 247526 120615 ;
        RECT 246876 120435 247526 120615 ;
        RECT 246876 120435 247526 120615 ;
        RECT 247526 120435 248566 120615 ;
        RECT 247526 120155 248566 120335 ;
        RECT 246876 119875 247526 120055 ;
        RECT 246876 119875 247526 120055 ;
        RECT 246876 119875 247526 120055 ;
        RECT 246876 119875 247526 120055 ;
        RECT 246876 119875 247526 120055 ;
        RECT 247526 119875 248566 120055 ;
        RECT 247526 119595 248566 119775 ;
        RECT 246876 119315 247526 119495 ;
        RECT 246876 119315 247526 119495 ;
        RECT 246876 119315 247526 119495 ;
        RECT 246876 119315 247526 119495 ;
        RECT 246876 119315 247526 119495 ;
        RECT 247526 119315 248566 119495 ;
        RECT 247526 119035 248566 119215 ;
        RECT 246876 118755 247526 118935 ;
        RECT 246876 118755 247526 118935 ;
        RECT 246876 118755 247526 118935 ;
        RECT 246876 118755 247526 118935 ;
        RECT 246876 118755 247526 118935 ;
        RECT 247526 118755 248566 118935 ;
        RECT 249026 118675 249386 125175 ;
        RECT 245836 118475 246876 118655 ;
        RECT 245186 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 124915 246876 125095 ;
        RECT 244676 124635 245836 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124635 246876 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124355 246876 124535 ;
        RECT 244676 124075 245836 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 124075 246876 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 123795 246876 123975 ;
        RECT 244676 123515 245836 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 123515 246876 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 123235 246876 123415 ;
        RECT 244676 122955 245836 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122955 246876 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122675 246876 122855 ;
        RECT 244676 122395 245836 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 122395 246876 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 122115 246876 122295 ;
        RECT 244676 121835 245836 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121835 246876 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121555 246876 121735 ;
        RECT 244676 121275 245836 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 121275 246876 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 120995 246876 121175 ;
        RECT 244676 120715 245836 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120715 246876 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120435 246876 120615 ;
        RECT 244676 120155 245836 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 120155 246876 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 119875 246876 120055 ;
        RECT 244676 119595 245836 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119595 246876 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119315 246876 119495 ;
        RECT 244676 119035 245836 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 245836 119035 246876 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 245836 118755 246876 118935 ;
        RECT 244146 118475 244676 125375 ;
        RECT 104080 66444 215042 177406 ;
        RECT 280424 56223 411826 187625 ;
        RECT 329190 267159 363060 268359 ;
        RECT 345525 260939 346725 274579 ;
        RECT 347925 265359 363060 266559 ;
        RECT 347325 260939 348525 266559 ;
        RECT 349725 263559 363060 264759 ;
        RECT 349125 260939 350325 264759 ;
        RECT 351525 261759 363060 262959 ;
        RECT 350925 260939 352125 262959 ;
        RECT 353325 260939 363060 261159 ;
        RECT 352725 260939 353925 261159 ;
        RECT 347925 268959 363060 270159 ;
        RECT 347325 268959 348525 274579 ;
        RECT 349725 270759 363060 271959 ;
        RECT 349125 270759 350325 274579 ;
        RECT 351525 272559 363060 273759 ;
        RECT 350925 272559 352125 274579 ;
        RECT 353325 274359 363060 274579 ;
        RECT 352725 274359 353925 274579 ;
        RECT 329190 268959 344325 270159 ;
        RECT 343725 268959 344925 274579 ;
        RECT 329190 270759 342525 271959 ;
        RECT 341925 270759 343125 274579 ;
        RECT 329190 272559 340725 273759 ;
        RECT 340125 272559 341325 274579 ;
        RECT 329190 274359 338925 274579 ;
        RECT 338325 274359 339525 274579 ;
        RECT 329190 265359 344325 266559 ;
        RECT 343725 260939 344925 266559 ;
        RECT 329190 263559 342525 264759 ;
        RECT 341925 260939 343125 264759 ;
        RECT 329190 261759 340725 262959 ;
        RECT 340125 260939 341325 262959 ;
        RECT 329190 260939 338925 261159 ;
        RECT 338325 260939 339525 261159 ;
        RECT 362630 260939 363060 274579 ;
        RECT 329190 260939 329620 274579 ;
        RECT 235466 99930 257246 101130 ;
        RECT 245756 95725 246956 105335 ;
        RECT 235466 101730 244556 102930 ;
        RECT 243956 101730 245156 105335 ;
        RECT 235466 103530 242756 104730 ;
        RECT 242156 103530 243356 105335 ;
        RECT 235466 105330 240956 105335 ;
        RECT 240356 105330 241556 105335 ;
        RECT 235466 98130 244556 99330 ;
        RECT 243956 95725 245156 99330 ;
        RECT 235466 96330 242756 97530 ;
        RECT 242156 95725 243356 97530 ;
        RECT 235466 95725 240956 95730 ;
        RECT 240356 95725 241556 95730 ;
        RECT 248156 98130 257246 99330 ;
        RECT 247556 95725 248756 99330 ;
        RECT 249956 96330 257246 97530 ;
        RECT 249356 95725 250556 97530 ;
        RECT 251756 95725 257246 95730 ;
        RECT 251156 95725 252356 95730 ;
        RECT 248156 101730 257246 102930 ;
        RECT 247556 101730 248756 105335 ;
        RECT 249956 103530 257246 104730 ;
        RECT 249356 103530 250556 105335 ;
        RECT 251756 105330 257246 105335 ;
        RECT 251156 105330 252356 105335 ;
        RECT 235466 95725 235896 105335 ;
        RECT 256816 95725 257246 105335 ;
      LAYER M6 ;
        RECT 247526 125195 248566 125375 ;
        RECT 247526 118475 248566 118655 ;
        RECT 247526 124635 248566 124815 ;
        RECT 247526 124635 248566 124815 ;
        RECT 247526 124635 248566 124815 ;
        RECT 247526 124635 248566 124815 ;
        RECT 247526 124635 248566 124815 ;
        RECT 247526 124075 248566 124255 ;
        RECT 247526 124075 248566 124255 ;
        RECT 247526 124075 248566 124255 ;
        RECT 247526 124075 248566 124255 ;
        RECT 247526 124075 248566 124255 ;
        RECT 247526 123515 248566 123695 ;
        RECT 247526 123515 248566 123695 ;
        RECT 247526 123515 248566 123695 ;
        RECT 247526 123515 248566 123695 ;
        RECT 247526 123515 248566 123695 ;
        RECT 247526 122955 248566 123135 ;
        RECT 247526 122955 248566 123135 ;
        RECT 247526 122955 248566 123135 ;
        RECT 247526 122955 248566 123135 ;
        RECT 247526 122955 248566 123135 ;
        RECT 247526 122395 248566 122575 ;
        RECT 247526 122395 248566 122575 ;
        RECT 247526 122395 248566 122575 ;
        RECT 247526 122395 248566 122575 ;
        RECT 247526 122395 248566 122575 ;
        RECT 247526 121835 248566 122015 ;
        RECT 247526 121835 248566 122015 ;
        RECT 247526 121835 248566 122015 ;
        RECT 247526 121835 248566 122015 ;
        RECT 247526 121835 248566 122015 ;
        RECT 247526 121275 248566 121455 ;
        RECT 247526 121275 248566 121455 ;
        RECT 247526 121275 248566 121455 ;
        RECT 247526 121275 248566 121455 ;
        RECT 247526 121275 248566 121455 ;
        RECT 247526 120715 248566 120895 ;
        RECT 247526 120715 248566 120895 ;
        RECT 247526 120715 248566 120895 ;
        RECT 247526 120715 248566 120895 ;
        RECT 247526 120715 248566 120895 ;
        RECT 247526 120155 248566 120335 ;
        RECT 247526 120155 248566 120335 ;
        RECT 247526 120155 248566 120335 ;
        RECT 247526 120155 248566 120335 ;
        RECT 247526 120155 248566 120335 ;
        RECT 247526 119595 248566 119775 ;
        RECT 247526 119595 248566 119775 ;
        RECT 247526 119595 248566 119775 ;
        RECT 247526 119595 248566 119775 ;
        RECT 247526 119595 248566 119775 ;
        RECT 247526 119035 248566 119215 ;
        RECT 247526 119035 248566 119215 ;
        RECT 247526 119035 248566 119215 ;
        RECT 247526 119035 248566 119215 ;
        RECT 247526 119035 248566 119215 ;
        RECT 249206 118675 249566 125175 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 245186 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 124635 246876 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124635 246876 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124635 246876 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124635 246876 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124635 246876 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124075 246876 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 124075 246876 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 124075 246876 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 124075 246876 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 124075 246876 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 123515 246876 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 123515 246876 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 123515 246876 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 123515 246876 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 123515 246876 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 122955 246876 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122955 246876 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122955 246876 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122955 246876 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122955 246876 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122395 246876 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 122395 246876 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 122395 246876 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 122395 246876 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 122395 246876 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 121835 246876 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121835 246876 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121835 246876 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121835 246876 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121835 246876 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121275 246876 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 121275 246876 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 121275 246876 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 121275 246876 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 121275 246876 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 120715 246876 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120715 246876 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120715 246876 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120715 246876 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120715 246876 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120155 246876 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 120155 246876 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 120155 246876 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 120155 246876 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 120155 246876 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 119595 246876 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119595 246876 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119595 246876 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119595 246876 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119595 246876 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119035 246876 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 245836 119035 246876 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 245836 119035 246876 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 245836 119035 246876 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 245836 119035 246876 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 244146 118475 244676 125375 ;
        RECT 104080 66444 215042 177406 ;
        RECT 280424 56223 411826 187625 ;
        RECT 347025 266259 363060 267459 ;
        RECT 346425 260939 347625 267459 ;
        RECT 348825 264459 363060 265659 ;
        RECT 348225 260939 349425 265659 ;
        RECT 350625 262659 363060 263859 ;
        RECT 350025 260939 351225 263859 ;
        RECT 352425 260939 363060 262059 ;
        RECT 351825 260939 353025 262059 ;
        RECT 347025 268059 363060 269259 ;
        RECT 346425 268059 347625 274579 ;
        RECT 348825 269859 363060 271059 ;
        RECT 348225 269859 349425 274579 ;
        RECT 350625 271659 363060 272859 ;
        RECT 350025 271659 351225 274579 ;
        RECT 352425 273459 363060 274579 ;
        RECT 351825 273459 353025 274579 ;
        RECT 329190 268059 345225 269259 ;
        RECT 344625 268059 345825 274579 ;
        RECT 329190 269859 343425 271059 ;
        RECT 342825 269859 344025 274579 ;
        RECT 329190 271659 341625 272859 ;
        RECT 341025 271659 342225 274579 ;
        RECT 329190 273459 339825 274579 ;
        RECT 339225 273459 340425 274579 ;
        RECT 329190 266259 345225 267459 ;
        RECT 344625 260939 345825 267459 ;
        RECT 329190 264459 343425 265659 ;
        RECT 342825 260939 344025 265659 ;
        RECT 329190 262659 341625 263859 ;
        RECT 341025 260939 342225 263859 ;
        RECT 329190 260939 339825 262059 ;
        RECT 339225 260939 340425 262059 ;
        RECT 362630 260939 363060 274579 ;
        RECT 329190 260939 329620 274579 ;
        RECT 235466 100830 245456 102030 ;
        RECT 244856 100830 246056 105335 ;
        RECT 235466 102630 243656 103830 ;
        RECT 243056 102630 244256 105335 ;
        RECT 235466 104430 241856 105335 ;
        RECT 241256 104430 242456 105335 ;
        RECT 235466 99030 245456 100230 ;
        RECT 244856 95725 246056 100230 ;
        RECT 235466 97230 243656 98430 ;
        RECT 243056 95725 244256 98430 ;
        RECT 235466 95725 241856 96630 ;
        RECT 241256 95725 242456 96630 ;
        RECT 247256 99030 257246 100230 ;
        RECT 246656 95725 247856 100230 ;
        RECT 249056 97230 257246 98430 ;
        RECT 248456 95725 249656 98430 ;
        RECT 250856 95725 257246 96630 ;
        RECT 250256 95725 251456 96630 ;
        RECT 247256 100830 257246 102030 ;
        RECT 246656 100830 247856 105335 ;
        RECT 249056 102630 257246 103830 ;
        RECT 248456 102630 249656 105335 ;
        RECT 250856 104430 257246 105335 ;
        RECT 250256 104430 251456 105335 ;
        RECT 235466 95725 235896 105335 ;
        RECT 256816 95725 257246 105335 ;
      LAYER M7 ;
        RECT 247526 118475 248566 126540 ;
        RECT 249386 118675 250086 125175 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 245186 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 125195 246876 125375 ;
        RECT 245836 118475 246876 118655 ;
        RECT 244676 125195 245836 125375 ;
        RECT 244676 118475 245836 118655 ;
        RECT 245836 124635 246876 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124635 246876 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124635 246876 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124635 246876 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124635 246876 124815 ;
        RECT 244676 124635 245836 124815 ;
        RECT 245836 124075 246876 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 124075 246876 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 124075 246876 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 124075 246876 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 124075 246876 124255 ;
        RECT 244676 124075 245836 124255 ;
        RECT 245836 123515 246876 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 123515 246876 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 123515 246876 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 123515 246876 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 123515 246876 123695 ;
        RECT 244676 123515 245836 123695 ;
        RECT 245836 122955 246876 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122955 246876 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122955 246876 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122955 246876 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122955 246876 123135 ;
        RECT 244676 122955 245836 123135 ;
        RECT 245836 122395 246876 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 122395 246876 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 122395 246876 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 122395 246876 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 122395 246876 122575 ;
        RECT 244676 122395 245836 122575 ;
        RECT 245836 121835 246876 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121835 246876 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121835 246876 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121835 246876 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121835 246876 122015 ;
        RECT 244676 121835 245836 122015 ;
        RECT 245836 121275 246876 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 121275 246876 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 121275 246876 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 121275 246876 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 121275 246876 121455 ;
        RECT 244676 121275 245836 121455 ;
        RECT 245836 120715 246876 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120715 246876 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120715 246876 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120715 246876 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120715 246876 120895 ;
        RECT 244676 120715 245836 120895 ;
        RECT 245836 120155 246876 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 120155 246876 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 120155 246876 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 120155 246876 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 120155 246876 120335 ;
        RECT 244676 120155 245836 120335 ;
        RECT 245836 119595 246876 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119595 246876 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119595 246876 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119595 246876 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119595 246876 119775 ;
        RECT 244676 119595 245836 119775 ;
        RECT 245836 119035 246876 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 245836 119035 246876 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 245836 119035 246876 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 245836 119035 246876 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 245836 119035 246876 119215 ;
        RECT 244676 119035 245836 119215 ;
        RECT 244146 118475 244676 125375 ;
        RECT 104080 66444 215042 177406 ;
        RECT 280424 56223 411826 187625 ;
      LAYER M8 ;
        RECT 160060 292079 210060 352079 ;
        RECT 161850 295269 208270 348889 ;
        RECT 249386 118675 250426 125175 ;
        RECT 243436 118475 244676 125375 ;
        RECT 170171 117425 202421 126425 ;
        RECT 104080 66444 215042 177406 ;
        RECT 344375 152439 347875 169439 ;
        RECT 280424 56223 411826 187625 ;
        RECT 480180 292079 530180 352079 ;
        RECT 481970 295269 528390 348889 ;
        RECT 400150 292079 450150 352079 ;
        RECT 401940 295269 448360 348889 ;
        RECT 240090 292079 290090 352079 ;
        RECT 241880 295269 288300 348889 ;
        RECT 320120 292079 370120 352079 ;
        RECT 321910 295269 368330 348889 ;
        RECT 0 160060 60000 210060 ;
        RECT 3190 161850 56810 208270 ;
        RECT 227976 117220 234466 118680 ;
        RECT 227976 125170 234466 126630 ;
        RECT 233626 118680 234466 125170 ;
        RECT 226296 121195 232786 122655 ;
        RECT 231186 119660 232646 124190 ;
        RECT 228116 119660 229576 124190 ;
        RECT 348145 260939 363060 274579 ;
        RECT 329190 260939 344105 274579 ;
        RECT 361400 258439 363060 260939 ;
        RECT 329190 258439 330850 260939 ;
        RECT 329190 258439 363060 260099 ;
        RECT 344945 260939 347305 277079 ;
        RECT 347305 270339 360560 272079 ;
        RECT 347305 270339 360560 272079 ;
        RECT 331690 270339 344945 272079 ;
        RECT 347305 266889 360560 268629 ;
        RECT 347305 266889 360560 268629 ;
        RECT 331690 266889 344945 268629 ;
        RECT 347305 263439 360560 265179 ;
        RECT 347305 263439 360560 265179 ;
        RECT 331690 263439 344945 265179 ;
        RECT 235466 95725 244336 105335 ;
        RECT 248376 95725 257246 105335 ;
        RECT 235466 105335 237126 107835 ;
        RECT 255586 105335 257246 107835 ;
        RECT 235466 106175 257246 107835 ;
        RECT 245176 93225 247536 105335 ;
        RECT 237966 98225 245176 99965 ;
        RECT 237966 98225 245176 99965 ;
        RECT 247536 98225 254746 99965 ;
        RECT 237966 101095 245176 102835 ;
        RECT 237966 101095 245176 102835 ;
        RECT 247536 101095 254746 102835 ;
        RECT 327980 195439 330880 257439 ;
        RECT 361370 195439 364270 257439 ;
        RECT 327980 195439 364270 197439 ;
        RECT 327980 198439 364270 200439 ;
        RECT 327980 201439 364270 203439 ;
        RECT 327980 204439 364270 206439 ;
        RECT 327980 207439 364270 209439 ;
        RECT 327980 210439 364270 212439 ;
        RECT 327980 213439 364270 215439 ;
        RECT 327980 216439 364270 218439 ;
        RECT 327980 219439 364270 221439 ;
        RECT 327980 222439 364270 224439 ;
        RECT 327980 225439 364270 227439 ;
        RECT 327980 228439 364270 230439 ;
        RECT 327980 231439 364270 233439 ;
        RECT 327980 234439 364270 236439 ;
        RECT 327980 237439 364270 239439 ;
        RECT 327980 240439 364270 242439 ;
        RECT 327980 243439 364270 245439 ;
        RECT 327980 246439 364270 248439 ;
        RECT 327980 249439 364270 251439 ;
        RECT 327980 252439 364270 254439 ;
        RECT 327980 255439 364270 257439 ;
      LAYER M9 ;
        RECT 160060 292079 210060 352079 ;
        RECT 161630 295049 208490 349109 ;
        RECT 249206 118675 251206 125175 ;
        RECT 242676 118475 244676 125375 ;
        RECT 193421 117425 225296 126425 ;
        RECT 128326 87785 190796 156065 ;
        RECT 155061 147065 164061 190565 ;
        RECT 104080 66444 215042 177406 ;
        RECT 344375 165939 347875 194439 ;
        RECT 303670 81159 388580 162689 ;
        RECT 271920 120174 307170 123674 ;
        RECT 280424 56223 411826 187625 ;
        RECT 480180 292079 530180 352079 ;
        RECT 481750 295049 528610 349109 ;
        RECT 400150 292079 450150 352079 ;
        RECT 401720 295049 448580 349109 ;
        RECT 240090 292079 290090 352079 ;
        RECT 241660 295049 288520 349109 ;
        RECT 320120 292079 370120 352079 ;
        RECT 321690 295049 368550 349109 ;
        RECT 246296 127730 249796 222730 ;
        RECT 0 160060 60000 210060 ;
        RECT 2970 161630 57030 208490 ;
        RECT 341390 196759 350860 256119 ;
        RECT 328980 196759 337450 256119 ;
        RECT 354800 196759 363270 256119 ;
        RECT 327980 195439 330880 257439 ;
        RECT 361370 195439 364270 257439 ;
    END
END lna

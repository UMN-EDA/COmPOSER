MACRO xc2_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc2_1 0 0 ;
  SIZE 26320 BY 21320 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 9978 20890 16342 21320 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 9978 0 16342 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 9480 1660 11840 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 24660 1760 26320 19560 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 12680 23820 21320 ;
    LAYER M8 ;
      RECT 2500 0 23820 8640 ;
    LAYER M8 ;
      RECT 23820 19660 26320 21320 ;
    LAYER M8 ;
      RECT 23820 0 26320 1660 ;
    LAYER M8 ;
      RECT 24660 0 26320 21320 ;
    LAYER M8 ;
      RECT 0 9480 23820 11840 ;
    LAYER M8 ;
      RECT 5000 11840 6740 18820 ;
    LAYER M8 ;
      RECT 5000 11840 6740 18820 ;
    LAYER M8 ;
      RECT 5000 2500 6740 9480 ;
    LAYER M8 ;
      RECT 7916 11840 9656 18820 ;
    LAYER M8 ;
      RECT 7916 11840 9656 18820 ;
    LAYER M8 ;
      RECT 7916 2500 9656 9480 ;
    LAYER M8 ;
      RECT 10832 11840 12572 18820 ;
    LAYER M8 ;
      RECT 10832 11840 12572 18820 ;
    LAYER M8 ;
      RECT 10832 2500 12572 9480 ;
    LAYER M8 ;
      RECT 13748 11840 15488 18820 ;
    LAYER M8 ;
      RECT 13748 11840 15488 18820 ;
    LAYER M8 ;
      RECT 13748 2500 15488 9480 ;
    LAYER M8 ;
      RECT 16664 11840 18404 18820 ;
    LAYER M8 ;
      RECT 16664 11840 18404 18820 ;
    LAYER M8 ;
      RECT 16664 2500 18404 9480 ;
    LAYER M8 ;
      RECT 19580 11840 21320 18820 ;
    LAYER M8 ;
      RECT 19580 11840 21320 18820 ;
    LAYER M8 ;
      RECT 19580 2500 21320 9480 ;
    LAYER M5 ;
      RECT 12560 0 13760 21320 ;
    LAYER M5 ;
      RECT 2500 10060 23820 11260 ;
    LAYER M5 ;
      RECT 14360 12460 15560 21320 ;
    LAYER M5 ;
      RECT 14360 11860 23820 13060 ;
    LAYER M5 ;
      RECT 16160 14260 17360 21320 ;
    LAYER M5 ;
      RECT 16160 13660 23820 14860 ;
    LAYER M5 ;
      RECT 17960 16060 19160 21320 ;
    LAYER M5 ;
      RECT 17960 15460 23820 16660 ;
    LAYER M5 ;
      RECT 19760 17860 20960 21320 ;
    LAYER M5 ;
      RECT 19760 17260 23820 18460 ;
    LAYER M5 ;
      RECT 21560 19660 22760 21320 ;
    LAYER M5 ;
      RECT 21560 19060 23820 20260 ;
    LAYER M5 ;
      RECT 23360 20860 23820 21320 ;
    LAYER M5 ;
      RECT 10760 12460 11960 21320 ;
    LAYER M5 ;
      RECT 2500 11860 11960 13060 ;
    LAYER M5 ;
      RECT 8960 14260 10160 21320 ;
    LAYER M5 ;
      RECT 2500 13660 10160 14860 ;
    LAYER M5 ;
      RECT 7160 16060 8360 21320 ;
    LAYER M5 ;
      RECT 2500 15460 8360 16660 ;
    LAYER M5 ;
      RECT 5360 17860 6560 21320 ;
    LAYER M5 ;
      RECT 2500 17260 6560 18460 ;
    LAYER M5 ;
      RECT 3560 19660 4760 21320 ;
    LAYER M5 ;
      RECT 2500 19060 4760 20260 ;
    LAYER M5 ;
      RECT 2500 20860 2960 21320 ;
    LAYER M5 ;
      RECT 10760 0 11960 8860 ;
    LAYER M5 ;
      RECT 2500 8260 11960 9460 ;
    LAYER M5 ;
      RECT 8960 0 10160 7060 ;
    LAYER M5 ;
      RECT 2500 6460 10160 7660 ;
    LAYER M5 ;
      RECT 7160 0 8360 5260 ;
    LAYER M5 ;
      RECT 2500 4660 8360 5860 ;
    LAYER M5 ;
      RECT 5360 0 6560 3460 ;
    LAYER M5 ;
      RECT 2500 2860 6560 4060 ;
    LAYER M5 ;
      RECT 3560 0 4760 1660 ;
    LAYER M5 ;
      RECT 2500 1060 4760 2260 ;
    LAYER M5 ;
      RECT 2500 0 2960 460 ;
    LAYER M5 ;
      RECT 14360 0 15560 8860 ;
    LAYER M5 ;
      RECT 14360 8260 23820 9460 ;
    LAYER M5 ;
      RECT 16160 0 17360 7060 ;
    LAYER M5 ;
      RECT 16160 6460 23820 7660 ;
    LAYER M5 ;
      RECT 17960 0 19160 5260 ;
    LAYER M5 ;
      RECT 17960 4660 23820 5860 ;
    LAYER M5 ;
      RECT 19760 0 20960 3460 ;
    LAYER M5 ;
      RECT 19760 2860 23820 4060 ;
    LAYER M5 ;
      RECT 21560 0 22760 1660 ;
    LAYER M5 ;
      RECT 21560 1060 23820 2260 ;
    LAYER M5 ;
      RECT 23360 0 23820 460 ;
    LAYER M5 ;
      RECT 2500 20890 23820 21320 ;
    LAYER M5 ;
      RECT 2500 0 23820 430 ;
    LAYER M6 ;
      RECT 13460 11560 14660 21320 ;
    LAYER M6 ;
      RECT 13460 10960 23820 12160 ;
    LAYER M6 ;
      RECT 15260 13360 16460 21320 ;
    LAYER M6 ;
      RECT 15260 12760 23820 13960 ;
    LAYER M6 ;
      RECT 17060 15160 18260 21320 ;
    LAYER M6 ;
      RECT 17060 14560 23820 15760 ;
    LAYER M6 ;
      RECT 18860 16960 20060 21320 ;
    LAYER M6 ;
      RECT 18860 16360 23820 17560 ;
    LAYER M6 ;
      RECT 20660 18760 21860 21320 ;
    LAYER M6 ;
      RECT 20660 18160 23820 19360 ;
    LAYER M6 ;
      RECT 22460 20560 23660 21320 ;
    LAYER M6 ;
      RECT 22460 19960 23820 21160 ;
    LAYER M6 ;
      RECT 11660 11560 12860 21320 ;
    LAYER M6 ;
      RECT 2500 10960 12860 12160 ;
    LAYER M6 ;
      RECT 9860 13360 11060 21320 ;
    LAYER M6 ;
      RECT 2500 12760 11060 13960 ;
    LAYER M6 ;
      RECT 8060 15160 9260 21320 ;
    LAYER M6 ;
      RECT 2500 14560 9260 15760 ;
    LAYER M6 ;
      RECT 6260 16960 7460 21320 ;
    LAYER M6 ;
      RECT 2500 16360 7460 17560 ;
    LAYER M6 ;
      RECT 4460 18760 5660 21320 ;
    LAYER M6 ;
      RECT 2500 18160 5660 19360 ;
    LAYER M6 ;
      RECT 2660 20560 3860 21320 ;
    LAYER M6 ;
      RECT 2500 19960 3860 21160 ;
    LAYER M6 ;
      RECT 11660 0 12860 9760 ;
    LAYER M6 ;
      RECT 2500 9160 12860 10360 ;
    LAYER M6 ;
      RECT 9860 0 11060 7960 ;
    LAYER M6 ;
      RECT 2500 7360 11060 8560 ;
    LAYER M6 ;
      RECT 8060 0 9260 6160 ;
    LAYER M6 ;
      RECT 2500 5560 9260 6760 ;
    LAYER M6 ;
      RECT 6260 0 7460 4360 ;
    LAYER M6 ;
      RECT 2500 3760 7460 4960 ;
    LAYER M6 ;
      RECT 4460 0 5660 2560 ;
    LAYER M6 ;
      RECT 2500 1960 5660 3160 ;
    LAYER M6 ;
      RECT 2660 0 3860 760 ;
    LAYER M6 ;
      RECT 2500 160 3860 1360 ;
    LAYER M6 ;
      RECT 13460 0 14660 9760 ;
    LAYER M6 ;
      RECT 13460 9160 23820 10360 ;
    LAYER M6 ;
      RECT 15260 0 16460 7960 ;
    LAYER M6 ;
      RECT 15260 7360 23820 8560 ;
    LAYER M6 ;
      RECT 17060 0 18260 6160 ;
    LAYER M6 ;
      RECT 17060 5560 23820 6760 ;
    LAYER M6 ;
      RECT 18860 0 20060 4360 ;
    LAYER M6 ;
      RECT 18860 3760 23820 4960 ;
    LAYER M6 ;
      RECT 20660 0 21860 2560 ;
    LAYER M6 ;
      RECT 20660 1960 23820 3160 ;
    LAYER M6 ;
      RECT 22460 0 23660 760 ;
    LAYER M6 ;
      RECT 22460 160 23820 1360 ;
    LAYER M6 ;
      RECT 2500 20890 23820 21320 ;
    LAYER M6 ;
      RECT 2500 0 23820 430 ;
  END
END xc2_1

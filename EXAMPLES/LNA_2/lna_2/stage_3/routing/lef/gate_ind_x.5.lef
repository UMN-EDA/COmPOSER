MACRO gate_ind_x.5
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gate_ind_x.5 0 0 ;
  SIZE 133620 BY 117738 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 130120 57119 133620 60619 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 57119 3500 60619 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 115120 53869 125120 63869 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 91495 57119 108745 60619 ;
    LAYER M8 ;
      RECT 7941 0 125679 117738 ;
    LAYER M9 ;
      RECT 105245 57119 133620 60619 ;
    LAYER M9 ;
      RECT 31750 25529 101870 92209 ;
    LAYER M9 ;
      RECT 0 57119 35250 60619 ;
    LAYER M9 ;
      RECT 7941 0 125679 117738 ;
    LAYER M1 ;
      RECT 7941 0 125679 117738 ;
    LAYER M2 ;
      RECT 7941 0 125679 117738 ;
    LAYER M3 ;
      RECT 7941 0 125679 117738 ;
    LAYER M4 ;
      RECT 7941 0 125679 117738 ;
    LAYER M5 ;
      RECT 7941 0 125679 117738 ;
    LAYER M6 ;
      RECT 7941 0 125679 117738 ;
    LAYER M7 ;
      RECT 7941 0 125679 117738 ;
  END
END gate_ind_x.5

MACRO xR3_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR3_0 0 0 ;
  SIZE 34480 BY 8860 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 8640 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 34160 220 34250 8640 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 34280 8640 ;
    LAYER RPO ;
      RECT 540 0 33940 8860 ;
    LAYER M1 ;
      RECT 230 235 320 8625 ;
    LAYER M1 ;
      RECT 34160 235 34250 8625 ;
    LAYER RH ;
      RECT 0 20 34480 8840 ;
  END
END xR3_0

MACRO drain_ind_x.25
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN drain_ind_x.25 0 0 ;
  SIZE 121216 BY 124121 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 112216 50981 121216 59981 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 50981 115121 59981 124121 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 100121 50481 110121 60481 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 66091 50981 98341 59981 ;
    LAYER M8 ;
      RECT 0 0 110962 110962 ;
    LAYER M9 ;
      RECT 89341 50981 121216 59981 ;
    LAYER M9 ;
      RECT 24246 21341 86716 89621 ;
    LAYER M9 ;
      RECT 50981 80621 59981 124121 ;
    LAYER M9 ;
      RECT 0 0 110962 110962 ;
    LAYER M1 ;
      RECT 0 0 110962 110962 ;
    LAYER M2 ;
      RECT 0 0 110962 110962 ;
    LAYER M3 ;
      RECT 0 0 110962 110962 ;
    LAYER M4 ;
      RECT 0 0 110962 110962 ;
    LAYER M5 ;
      RECT 0 0 110962 110962 ;
    LAYER M6 ;
      RECT 0 0 110962 110962 ;
    LAYER M7 ;
      RECT 0 0 110962 110962 ;
  END
END drain_ind_x.25

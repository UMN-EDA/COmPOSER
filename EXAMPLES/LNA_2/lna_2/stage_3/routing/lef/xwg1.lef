MACRO xwg1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xwg1 0 0 ;
  SIZE 62000 BY 36290 ;
  PIN GND1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 26265 1000 35735 9470 ;
    END
  END GND1
  PIN GND2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 26265 26820 35735 35290 ;
    END
  END GND2
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1320 13410 10790 22880 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 51210 13410 60680 22880 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 1320 13410 60680 22880 ;
    LAYER M9 ;
      RECT 1320 26820 60680 35290 ;
    LAYER M9 ;
      RECT 1320 1000 60680 9470 ;
    LAYER M9 ;
      RECT 0 33390 62000 36290 ;
    LAYER M9 ;
      RECT 0 0 62000 2900 ;
    LAYER M8 ;
      RECT 0 33390 62000 36290 ;
    LAYER M8 ;
      RECT 0 0 62000 2900 ;
    LAYER M8 ;
      RECT 0 0 2000 36290 ;
    LAYER M8 ;
      RECT 3000 0 5000 36290 ;
    LAYER M8 ;
      RECT 6000 0 8000 36290 ;
    LAYER M8 ;
      RECT 9000 0 11000 36290 ;
    LAYER M8 ;
      RECT 12000 0 14000 36290 ;
    LAYER M8 ;
      RECT 15000 0 17000 36290 ;
    LAYER M8 ;
      RECT 18000 0 20000 36290 ;
    LAYER M8 ;
      RECT 21000 0 23000 36290 ;
    LAYER M8 ;
      RECT 24000 0 26000 36290 ;
    LAYER M8 ;
      RECT 27000 0 29000 36290 ;
    LAYER M8 ;
      RECT 30000 0 32000 36290 ;
    LAYER M8 ;
      RECT 33000 0 35000 36290 ;
    LAYER M8 ;
      RECT 36000 0 38000 36290 ;
    LAYER M8 ;
      RECT 39000 0 41000 36290 ;
    LAYER M8 ;
      RECT 42000 0 44000 36290 ;
    LAYER M8 ;
      RECT 45000 0 47000 36290 ;
    LAYER M8 ;
      RECT 48000 0 50000 36290 ;
    LAYER M8 ;
      RECT 51000 0 53000 36290 ;
    LAYER M8 ;
      RECT 54000 0 56000 36290 ;
    LAYER M8 ;
      RECT 57000 0 59000 36290 ;
    LAYER M8 ;
      RECT 60000 0 62000 36290 ;
  END
END xwg1

MACRO gate_ind_x.25
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gate_ind_x.25 0 0 ;
  SIZE 138216 BY 139906 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 134716 63951 138216 67451 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 63951 136406 67451 139906 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 121406 60701 131406 70701 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 96216 63951 113216 67451 ;
    LAYER M8 ;
      RECT 0 0 131402 131402 ;
    LAYER M9 ;
      RECT 109716 63951 138216 67451 ;
    LAYER M9 ;
      RECT 24936 23246 106466 108156 ;
    LAYER M9 ;
      RECT 63951 104656 67451 139906 ;
    LAYER M9 ;
      RECT 0 0 131402 131402 ;
    LAYER M1 ;
      RECT 0 0 131402 131402 ;
    LAYER M2 ;
      RECT 0 0 131402 131402 ;
    LAYER M3 ;
      RECT 0 0 131402 131402 ;
    LAYER M4 ;
      RECT 0 0 131402 131402 ;
    LAYER M5 ;
      RECT 0 0 131402 131402 ;
    LAYER M6 ;
      RECT 0 0 131402 131402 ;
    LAYER M7 ;
      RECT 0 0 131402 131402 ;
  END
END gate_ind_x.25

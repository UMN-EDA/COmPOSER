MACRO xR0_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR0_1 0 0 ;
  SIZE 28920 BY 8860 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 8640 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 28600 220 28690 8640 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 28720 8640 ;
    LAYER RPO ;
      RECT 540 0 28380 8860 ;
    LAYER M1 ;
      RECT 230 235 320 8625 ;
    LAYER M1 ;
      RECT 28600 235 28690 8625 ;
    LAYER RH ;
      RECT 0 20 28920 8840 ;
  END
END xR0_1

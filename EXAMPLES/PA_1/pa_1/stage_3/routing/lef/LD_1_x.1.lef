MACRO LD_1_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_1_x.1 0 0 ;
  SIZE 120353 BY 113106 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 117353 58178 120353 61178 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 117353 51928 120353 54928 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 102353 51553 112353 61553 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 73353 58178 88853 61178 ;
    LAYER M8 ;
      RECT 0 0 113106 113106 ;
    LAYER M9 ;
      RECT 85853 58178 120353 61178 ;
    LAYER M9 ;
      RECT 24253 25813 88853 87293 ;
    LAYER M9 ;
      RECT 85853 51928 120353 54928 ;
    LAYER M9 ;
      RECT 0 0 113106 113106 ;
    LAYER M1 ;
      RECT 0 0 113106 113106 ;
    LAYER M2 ;
      RECT 0 0 113106 113106 ;
    LAYER M3 ;
      RECT 0 0 113106 113106 ;
    LAYER M4 ;
      RECT 0 0 113106 113106 ;
    LAYER M5 ;
      RECT 0 0 113106 113106 ;
    LAYER M6 ;
      RECT 0 0 113106 113106 ;
    LAYER M7 ;
      RECT 0 0 113106 113106 ;
  END
END LD_1_x.1

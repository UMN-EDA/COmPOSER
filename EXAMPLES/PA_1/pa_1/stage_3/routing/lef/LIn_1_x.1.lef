MACRO LIn_1_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_1_x.1 0 0 ;
  SIZE 135501 BY 127652 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 132501 65326 135501 68326 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 132501 59326 135501 62326 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 117501 58826 127501 68826 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 83001 65326 104001 68326 ;
    LAYER M8 ;
      RECT 0 0 127652 127652 ;
    LAYER M9 ;
      RECT 101001 65326 135501 68326 ;
    LAYER M9 ;
      RECT 23651 25151 104001 102501 ;
    LAYER M9 ;
      RECT 101001 59326 135501 62326 ;
    LAYER M9 ;
      RECT 0 0 127652 127652 ;
    LAYER M1 ;
      RECT 0 0 127652 127652 ;
    LAYER M2 ;
      RECT 0 0 127652 127652 ;
    LAYER M3 ;
      RECT 0 0 127652 127652 ;
    LAYER M4 ;
      RECT 0 0 127652 127652 ;
    LAYER M5 ;
      RECT 0 0 127652 127652 ;
    LAYER M6 ;
      RECT 0 0 127652 127652 ;
    LAYER M7 ;
      RECT 0 0 127652 127652 ;
  END
END LIn_1_x.1

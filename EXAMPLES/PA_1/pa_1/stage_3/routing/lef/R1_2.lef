MACRO R1_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R1_2 0 0 ;
  SIZE 5860 BY 4960 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4740 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 5540 220 5630 4740 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 5660 4740 ;
    LAYER RPO ;
      RECT 540 0 5320 4960 ;
    LAYER M1 ;
      RECT 230 235 320 4725 ;
    LAYER M1 ;
      RECT 5540 235 5630 4725 ;
    LAYER RH ;
      RECT 0 20 5860 4940 ;
  END
END R1_2

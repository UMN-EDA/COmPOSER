MACRO LD_1_x.25
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_1_x.25 0 0 ;
  SIZE 112909 BY 114474 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 109909 52229 112909 55229 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 52229 111474 55229 114474 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 96474 48729 106474 58729 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 65909 52229 87659 55229 ;
    LAYER M8 ;
      RECT 0 0 107458 107458 ;
    LAYER M9 ;
      RECT 84659 52229 112909 55229 ;
    LAYER M9 ;
      RECT 26049 24484 81409 82974 ;
    LAYER M9 ;
      RECT 52229 79974 55229 114474 ;
    LAYER M9 ;
      RECT 0 0 107458 107458 ;
    LAYER M1 ;
      RECT 0 0 107458 107458 ;
    LAYER M2 ;
      RECT 0 0 107458 107458 ;
    LAYER M3 ;
      RECT 0 0 107458 107458 ;
    LAYER M4 ;
      RECT 0 0 107458 107458 ;
    LAYER M5 ;
      RECT 0 0 107458 107458 ;
    LAYER M6 ;
      RECT 0 0 107458 107458 ;
    LAYER M7 ;
      RECT 0 0 107458 107458 ;
  END
END LD_1_x.25

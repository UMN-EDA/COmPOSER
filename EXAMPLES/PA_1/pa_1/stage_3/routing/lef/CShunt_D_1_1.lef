MACRO CShunt_D_1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CShunt_D_1_1 0 0 ;
  SIZE 8290 BY 9730 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 9630 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 7010 4135 8290 5595 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 8170 6610 9630 ;
    LAYER M8 ;
      RECT 0 100 6610 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 8170 ;
    LAYER M8 ;
      RECT 1680 4135 8290 5595 ;
    LAYER M8 ;
      RECT 1820 2540 3280 7190 ;
    LAYER M8 ;
      RECT 5010 2540 6470 7190 ;
  END
END CShunt_D_1_1

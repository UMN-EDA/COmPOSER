MACRO CSeries_D_1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CSeries_D_1_1 0 0 ;
  SIZE 20520 BY 15520 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8045 15090 12475 15520 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8045 0 12475 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 6580 1660 8940 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 18860 1760 20520 13760 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 9780 18020 15520 ;
    LAYER M8 ;
      RECT 2500 0 18020 5740 ;
    LAYER M8 ;
      RECT 18020 13860 20520 15520 ;
    LAYER M8 ;
      RECT 18020 0 20520 1660 ;
    LAYER M8 ;
      RECT 18860 0 20520 15520 ;
    LAYER M8 ;
      RECT 0 6580 18020 8940 ;
    LAYER M8 ;
      RECT 5000 8940 6740 13020 ;
    LAYER M8 ;
      RECT 5000 8940 6740 13020 ;
    LAYER M8 ;
      RECT 5000 2500 6740 6580 ;
    LAYER M8 ;
      RECT 7927 8940 9667 13020 ;
    LAYER M8 ;
      RECT 7927 8940 9667 13020 ;
    LAYER M8 ;
      RECT 7927 2500 9667 6580 ;
    LAYER M8 ;
      RECT 10853 8940 12593 13020 ;
    LAYER M8 ;
      RECT 10853 8940 12593 13020 ;
    LAYER M8 ;
      RECT 10853 2500 12593 6580 ;
    LAYER M8 ;
      RECT 13780 8940 15520 13020 ;
    LAYER M8 ;
      RECT 13780 8940 15520 13020 ;
    LAYER M8 ;
      RECT 13780 2500 15520 6580 ;
    LAYER M5 ;
      RECT 9660 0 10860 15520 ;
    LAYER M5 ;
      RECT 2500 7160 18020 8360 ;
    LAYER M5 ;
      RECT 11460 9560 12660 15520 ;
    LAYER M5 ;
      RECT 11460 8960 18020 10160 ;
    LAYER M5 ;
      RECT 13260 11360 14460 15520 ;
    LAYER M5 ;
      RECT 13260 10760 18020 11960 ;
    LAYER M5 ;
      RECT 15060 13160 16260 15520 ;
    LAYER M5 ;
      RECT 15060 12560 18020 13760 ;
    LAYER M5 ;
      RECT 16860 14960 18020 15520 ;
    LAYER M5 ;
      RECT 16860 14360 18020 15520 ;
    LAYER M5 ;
      RECT 7860 9560 9060 15520 ;
    LAYER M5 ;
      RECT 2500 8960 9060 10160 ;
    LAYER M5 ;
      RECT 6060 11360 7260 15520 ;
    LAYER M5 ;
      RECT 2500 10760 7260 11960 ;
    LAYER M5 ;
      RECT 4260 13160 5460 15520 ;
    LAYER M5 ;
      RECT 2500 12560 5460 13760 ;
    LAYER M5 ;
      RECT 2500 14960 3660 15520 ;
    LAYER M5 ;
      RECT 2500 14360 3660 15520 ;
    LAYER M5 ;
      RECT 7860 0 9060 5960 ;
    LAYER M5 ;
      RECT 2500 5360 9060 6560 ;
    LAYER M5 ;
      RECT 6060 0 7260 4160 ;
    LAYER M5 ;
      RECT 2500 3560 7260 4760 ;
    LAYER M5 ;
      RECT 4260 0 5460 2360 ;
    LAYER M5 ;
      RECT 2500 1760 5460 2960 ;
    LAYER M5 ;
      RECT 2500 0 3660 560 ;
    LAYER M5 ;
      RECT 2500 0 3660 1160 ;
    LAYER M5 ;
      RECT 11460 0 12660 5960 ;
    LAYER M5 ;
      RECT 11460 5360 18020 6560 ;
    LAYER M5 ;
      RECT 13260 0 14460 4160 ;
    LAYER M5 ;
      RECT 13260 3560 18020 4760 ;
    LAYER M5 ;
      RECT 15060 0 16260 2360 ;
    LAYER M5 ;
      RECT 15060 1760 18020 2960 ;
    LAYER M5 ;
      RECT 16860 0 18020 560 ;
    LAYER M5 ;
      RECT 16860 0 18020 1160 ;
    LAYER M5 ;
      RECT 2500 15090 18020 15520 ;
    LAYER M5 ;
      RECT 2500 0 18020 430 ;
    LAYER M6 ;
      RECT 10560 8660 11760 15520 ;
    LAYER M6 ;
      RECT 10560 8060 18020 9260 ;
    LAYER M6 ;
      RECT 12360 10460 13560 15520 ;
    LAYER M6 ;
      RECT 12360 9860 18020 11060 ;
    LAYER M6 ;
      RECT 14160 12260 15360 15520 ;
    LAYER M6 ;
      RECT 14160 11660 18020 12860 ;
    LAYER M6 ;
      RECT 15960 14060 17160 15520 ;
    LAYER M6 ;
      RECT 15960 13460 18020 14660 ;
    LAYER M6 ;
      RECT 8760 8660 9960 15520 ;
    LAYER M6 ;
      RECT 2500 8060 9960 9260 ;
    LAYER M6 ;
      RECT 6960 10460 8160 15520 ;
    LAYER M6 ;
      RECT 2500 9860 8160 11060 ;
    LAYER M6 ;
      RECT 5160 12260 6360 15520 ;
    LAYER M6 ;
      RECT 2500 11660 6360 12860 ;
    LAYER M6 ;
      RECT 3360 14060 4560 15520 ;
    LAYER M6 ;
      RECT 2500 13460 4560 14660 ;
    LAYER M6 ;
      RECT 8760 0 9960 6860 ;
    LAYER M6 ;
      RECT 2500 6260 9960 7460 ;
    LAYER M6 ;
      RECT 6960 0 8160 5060 ;
    LAYER M6 ;
      RECT 2500 4460 8160 5660 ;
    LAYER M6 ;
      RECT 5160 0 6360 3260 ;
    LAYER M6 ;
      RECT 2500 2660 6360 3860 ;
    LAYER M6 ;
      RECT 3360 0 4560 1460 ;
    LAYER M6 ;
      RECT 2500 860 4560 2060 ;
    LAYER M6 ;
      RECT 10560 0 11760 6860 ;
    LAYER M6 ;
      RECT 10560 6260 18020 7460 ;
    LAYER M6 ;
      RECT 12360 0 13560 5060 ;
    LAYER M6 ;
      RECT 12360 4460 18020 5660 ;
    LAYER M6 ;
      RECT 14160 0 15360 3260 ;
    LAYER M6 ;
      RECT 14160 2660 18020 3860 ;
    LAYER M6 ;
      RECT 15960 0 17160 1460 ;
    LAYER M6 ;
      RECT 15960 860 18020 2060 ;
    LAYER M6 ;
      RECT 2500 15090 18020 15520 ;
    LAYER M6 ;
      RECT 2500 0 18020 430 ;
  END
END CSeries_D_1_1

MACRO C28_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN C28_1 0 0 ;
  SIZE 20660 BY 15660 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 15230 12568 15660 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 0 12568 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 6650 1660 9010 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 19000 1760 20660 13900 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 9850 18160 15660 ;
    LAYER M8 ;
      RECT 2500 0 18160 5810 ;
    LAYER M8 ;
      RECT 18160 14000 20660 15660 ;
    LAYER M8 ;
      RECT 18160 0 20660 1660 ;
    LAYER M8 ;
      RECT 19000 0 20660 15660 ;
    LAYER M8 ;
      RECT 0 6650 18160 9010 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 2500 6740 6650 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 2500 9713 6650 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 2500 12687 6650 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 2500 15660 6650 ;
    LAYER M5 ;
      RECT 9730 0 10930 15660 ;
    LAYER M5 ;
      RECT 2500 7230 18160 8430 ;
    LAYER M5 ;
      RECT 11530 9630 12730 15660 ;
    LAYER M5 ;
      RECT 11530 9030 18160 10230 ;
    LAYER M5 ;
      RECT 13330 11430 14530 15660 ;
    LAYER M5 ;
      RECT 13330 10830 18160 12030 ;
    LAYER M5 ;
      RECT 15130 13230 16330 15660 ;
    LAYER M5 ;
      RECT 15130 12630 18160 13830 ;
    LAYER M5 ;
      RECT 16930 15030 18130 15660 ;
    LAYER M5 ;
      RECT 16930 14430 18160 15630 ;
    LAYER M5 ;
      RECT 7930 9630 9130 15660 ;
    LAYER M5 ;
      RECT 2500 9030 9130 10230 ;
    LAYER M5 ;
      RECT 6130 11430 7330 15660 ;
    LAYER M5 ;
      RECT 2500 10830 7330 12030 ;
    LAYER M5 ;
      RECT 4330 13230 5530 15660 ;
    LAYER M5 ;
      RECT 2500 12630 5530 13830 ;
    LAYER M5 ;
      RECT 2530 15030 3730 15660 ;
    LAYER M5 ;
      RECT 2500 14430 3730 15630 ;
    LAYER M5 ;
      RECT 7930 0 9130 6030 ;
    LAYER M5 ;
      RECT 2500 5430 9130 6630 ;
    LAYER M5 ;
      RECT 6130 0 7330 4230 ;
    LAYER M5 ;
      RECT 2500 3630 7330 4830 ;
    LAYER M5 ;
      RECT 4330 0 5530 2430 ;
    LAYER M5 ;
      RECT 2500 1830 5530 3030 ;
    LAYER M5 ;
      RECT 2530 0 3730 630 ;
    LAYER M5 ;
      RECT 2500 30 3730 1230 ;
    LAYER M5 ;
      RECT 11530 0 12730 6030 ;
    LAYER M5 ;
      RECT 11530 5430 18160 6630 ;
    LAYER M5 ;
      RECT 13330 0 14530 4230 ;
    LAYER M5 ;
      RECT 13330 3630 18160 4830 ;
    LAYER M5 ;
      RECT 15130 0 16330 2430 ;
    LAYER M5 ;
      RECT 15130 1830 18160 3030 ;
    LAYER M5 ;
      RECT 16930 0 18130 630 ;
    LAYER M5 ;
      RECT 16930 30 18160 1230 ;
    LAYER M5 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M5 ;
      RECT 2500 0 18160 430 ;
    LAYER M6 ;
      RECT 10630 8730 11830 15660 ;
    LAYER M6 ;
      RECT 10630 8130 18160 9330 ;
    LAYER M6 ;
      RECT 12430 10530 13630 15660 ;
    LAYER M6 ;
      RECT 12430 9930 18160 11130 ;
    LAYER M6 ;
      RECT 14230 12330 15430 15660 ;
    LAYER M6 ;
      RECT 14230 11730 18160 12930 ;
    LAYER M6 ;
      RECT 16030 14130 17230 15660 ;
    LAYER M6 ;
      RECT 16030 13530 18160 14730 ;
    LAYER M6 ;
      RECT 8830 8730 10030 15660 ;
    LAYER M6 ;
      RECT 2500 8130 10030 9330 ;
    LAYER M6 ;
      RECT 7030 10530 8230 15660 ;
    LAYER M6 ;
      RECT 2500 9930 8230 11130 ;
    LAYER M6 ;
      RECT 5230 12330 6430 15660 ;
    LAYER M6 ;
      RECT 2500 11730 6430 12930 ;
    LAYER M6 ;
      RECT 3430 14130 4630 15660 ;
    LAYER M6 ;
      RECT 2500 13530 4630 14730 ;
    LAYER M6 ;
      RECT 8830 0 10030 6930 ;
    LAYER M6 ;
      RECT 2500 6330 10030 7530 ;
    LAYER M6 ;
      RECT 7030 0 8230 5130 ;
    LAYER M6 ;
      RECT 2500 4530 8230 5730 ;
    LAYER M6 ;
      RECT 5230 0 6430 3330 ;
    LAYER M6 ;
      RECT 2500 2730 6430 3930 ;
    LAYER M6 ;
      RECT 3430 0 4630 1530 ;
    LAYER M6 ;
      RECT 2500 930 4630 2130 ;
    LAYER M6 ;
      RECT 10630 0 11830 6930 ;
    LAYER M6 ;
      RECT 10630 6330 18160 7530 ;
    LAYER M6 ;
      RECT 12430 0 13630 5130 ;
    LAYER M6 ;
      RECT 12430 4530 18160 5730 ;
    LAYER M6 ;
      RECT 14230 0 15430 3330 ;
    LAYER M6 ;
      RECT 14230 2730 18160 3930 ;
    LAYER M6 ;
      RECT 16030 0 17230 1530 ;
    LAYER M6 ;
      RECT 16030 930 18160 2130 ;
    LAYER M6 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M6 ;
      RECT 2500 0 18160 430 ;
  END
END C28_1
MACRO C28_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN C28_2 0 0 ;
  SIZE 16470 BY 19420 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6695 18990 9775 19420 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6695 0 9775 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 8530 1660 10890 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 14810 5735 16470 13685 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 11730 13970 19420 ;
    LAYER M8 ;
      RECT 2500 0 13970 7690 ;
    LAYER M8 ;
      RECT 13970 17760 16470 19420 ;
    LAYER M8 ;
      RECT 13970 0 16470 1660 ;
    LAYER M8 ;
      RECT 14810 0 16470 19420 ;
    LAYER M8 ;
      RECT 0 8530 13970 10890 ;
    LAYER M8 ;
      RECT 5000 10890 6740 16920 ;
    LAYER M8 ;
      RECT 5000 10890 6740 16920 ;
    LAYER M8 ;
      RECT 5000 2500 6740 8530 ;
    LAYER M8 ;
      RECT 9730 10890 11470 16920 ;
    LAYER M8 ;
      RECT 9730 10890 11470 16920 ;
    LAYER M8 ;
      RECT 9730 2500 11470 8530 ;
    LAYER M5 ;
      RECT 7635 0 8835 19420 ;
    LAYER M5 ;
      RECT 2500 9110 13970 10310 ;
    LAYER M5 ;
      RECT 9435 11510 10635 19420 ;
    LAYER M5 ;
      RECT 9435 10910 13970 12110 ;
    LAYER M5 ;
      RECT 11235 13310 12435 19420 ;
    LAYER M5 ;
      RECT 11235 12710 13970 13910 ;
    LAYER M5 ;
      RECT 13035 15110 13970 19420 ;
    LAYER M5 ;
      RECT 13035 14510 13970 15710 ;
    LAYER M5 ;
      RECT 5835 11510 7035 19420 ;
    LAYER M5 ;
      RECT 2500 10910 7035 12110 ;
    LAYER M5 ;
      RECT 4035 13310 5235 19420 ;
    LAYER M5 ;
      RECT 2500 12710 5235 13910 ;
    LAYER M5 ;
      RECT 2500 15110 3435 19420 ;
    LAYER M5 ;
      RECT 2500 14510 3435 15710 ;
    LAYER M5 ;
      RECT 5835 0 7035 7910 ;
    LAYER M5 ;
      RECT 2500 7310 7035 8510 ;
    LAYER M5 ;
      RECT 4035 0 5235 6110 ;
    LAYER M5 ;
      RECT 2500 5510 5235 6710 ;
    LAYER M5 ;
      RECT 2500 0 3435 4310 ;
    LAYER M5 ;
      RECT 2500 3710 3435 4910 ;
    LAYER M5 ;
      RECT 9435 0 10635 7910 ;
    LAYER M5 ;
      RECT 9435 7310 13970 8510 ;
    LAYER M5 ;
      RECT 11235 0 12435 6110 ;
    LAYER M5 ;
      RECT 11235 5510 13970 6710 ;
    LAYER M5 ;
      RECT 13035 0 13970 4310 ;
    LAYER M5 ;
      RECT 13035 3710 13970 4910 ;
    LAYER M5 ;
      RECT 2500 18990 13970 19420 ;
    LAYER M5 ;
      RECT 2500 0 13970 430 ;
    LAYER M6 ;
      RECT 8535 10610 9735 19420 ;
    LAYER M6 ;
      RECT 8535 10010 13970 11210 ;
    LAYER M6 ;
      RECT 10335 12410 11535 19420 ;
    LAYER M6 ;
      RECT 10335 11810 13970 13010 ;
    LAYER M6 ;
      RECT 12135 14210 13335 19420 ;
    LAYER M6 ;
      RECT 12135 13610 13970 14810 ;
    LAYER M6 ;
      RECT 6735 10610 7935 19420 ;
    LAYER M6 ;
      RECT 2500 10010 7935 11210 ;
    LAYER M6 ;
      RECT 4935 12410 6135 19420 ;
    LAYER M6 ;
      RECT 2500 11810 6135 13010 ;
    LAYER M6 ;
      RECT 3135 14210 4335 19420 ;
    LAYER M6 ;
      RECT 2500 13610 4335 14810 ;
    LAYER M6 ;
      RECT 6735 0 7935 8810 ;
    LAYER M6 ;
      RECT 2500 8210 7935 9410 ;
    LAYER M6 ;
      RECT 4935 0 6135 7010 ;
    LAYER M6 ;
      RECT 2500 6410 6135 7610 ;
    LAYER M6 ;
      RECT 3135 0 4335 5210 ;
    LAYER M6 ;
      RECT 2500 4610 4335 5810 ;
    LAYER M6 ;
      RECT 8535 0 9735 8810 ;
    LAYER M6 ;
      RECT 8535 8210 13970 9410 ;
    LAYER M6 ;
      RECT 10335 0 11535 7010 ;
    LAYER M6 ;
      RECT 10335 6410 13970 7610 ;
    LAYER M6 ;
      RECT 12135 0 13335 5210 ;
    LAYER M6 ;
      RECT 12135 4610 13970 5810 ;
    LAYER M6 ;
      RECT 2500 18990 13970 19420 ;
    LAYER M6 ;
      RECT 2500 0 13970 430 ;
  END
END C28_2
MACRO C29_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN C29_1 0 0 ;
  SIZE 20660 BY 15660 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 15230 12568 15660 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 0 12568 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 6650 1660 9010 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 19000 1760 20660 13900 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 9850 18160 15660 ;
    LAYER M8 ;
      RECT 2500 0 18160 5810 ;
    LAYER M8 ;
      RECT 18160 14000 20660 15660 ;
    LAYER M8 ;
      RECT 18160 0 20660 1660 ;
    LAYER M8 ;
      RECT 19000 0 20660 15660 ;
    LAYER M8 ;
      RECT 0 6650 18160 9010 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 2500 6740 6650 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 2500 9713 6650 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 2500 12687 6650 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 2500 15660 6650 ;
    LAYER M5 ;
      RECT 9730 0 10930 15660 ;
    LAYER M5 ;
      RECT 2500 7230 18160 8430 ;
    LAYER M5 ;
      RECT 11530 9630 12730 15660 ;
    LAYER M5 ;
      RECT 11530 9030 18160 10230 ;
    LAYER M5 ;
      RECT 13330 11430 14530 15660 ;
    LAYER M5 ;
      RECT 13330 10830 18160 12030 ;
    LAYER M5 ;
      RECT 15130 13230 16330 15660 ;
    LAYER M5 ;
      RECT 15130 12630 18160 13830 ;
    LAYER M5 ;
      RECT 16930 15030 18130 15660 ;
    LAYER M5 ;
      RECT 16930 14430 18160 15630 ;
    LAYER M5 ;
      RECT 7930 9630 9130 15660 ;
    LAYER M5 ;
      RECT 2500 9030 9130 10230 ;
    LAYER M5 ;
      RECT 6130 11430 7330 15660 ;
    LAYER M5 ;
      RECT 2500 10830 7330 12030 ;
    LAYER M5 ;
      RECT 4330 13230 5530 15660 ;
    LAYER M5 ;
      RECT 2500 12630 5530 13830 ;
    LAYER M5 ;
      RECT 2530 15030 3730 15660 ;
    LAYER M5 ;
      RECT 2500 14430 3730 15630 ;
    LAYER M5 ;
      RECT 7930 0 9130 6030 ;
    LAYER M5 ;
      RECT 2500 5430 9130 6630 ;
    LAYER M5 ;
      RECT 6130 0 7330 4230 ;
    LAYER M5 ;
      RECT 2500 3630 7330 4830 ;
    LAYER M5 ;
      RECT 4330 0 5530 2430 ;
    LAYER M5 ;
      RECT 2500 1830 5530 3030 ;
    LAYER M5 ;
      RECT 2530 0 3730 630 ;
    LAYER M5 ;
      RECT 2500 30 3730 1230 ;
    LAYER M5 ;
      RECT 11530 0 12730 6030 ;
    LAYER M5 ;
      RECT 11530 5430 18160 6630 ;
    LAYER M5 ;
      RECT 13330 0 14530 4230 ;
    LAYER M5 ;
      RECT 13330 3630 18160 4830 ;
    LAYER M5 ;
      RECT 15130 0 16330 2430 ;
    LAYER M5 ;
      RECT 15130 1830 18160 3030 ;
    LAYER M5 ;
      RECT 16930 0 18130 630 ;
    LAYER M5 ;
      RECT 16930 30 18160 1230 ;
    LAYER M5 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M5 ;
      RECT 2500 0 18160 430 ;
    LAYER M6 ;
      RECT 10630 8730 11830 15660 ;
    LAYER M6 ;
      RECT 10630 8130 18160 9330 ;
    LAYER M6 ;
      RECT 12430 10530 13630 15660 ;
    LAYER M6 ;
      RECT 12430 9930 18160 11130 ;
    LAYER M6 ;
      RECT 14230 12330 15430 15660 ;
    LAYER M6 ;
      RECT 14230 11730 18160 12930 ;
    LAYER M6 ;
      RECT 16030 14130 17230 15660 ;
    LAYER M6 ;
      RECT 16030 13530 18160 14730 ;
    LAYER M6 ;
      RECT 8830 8730 10030 15660 ;
    LAYER M6 ;
      RECT 2500 8130 10030 9330 ;
    LAYER M6 ;
      RECT 7030 10530 8230 15660 ;
    LAYER M6 ;
      RECT 2500 9930 8230 11130 ;
    LAYER M6 ;
      RECT 5230 12330 6430 15660 ;
    LAYER M6 ;
      RECT 2500 11730 6430 12930 ;
    LAYER M6 ;
      RECT 3430 14130 4630 15660 ;
    LAYER M6 ;
      RECT 2500 13530 4630 14730 ;
    LAYER M6 ;
      RECT 8830 0 10030 6930 ;
    LAYER M6 ;
      RECT 2500 6330 10030 7530 ;
    LAYER M6 ;
      RECT 7030 0 8230 5130 ;
    LAYER M6 ;
      RECT 2500 4530 8230 5730 ;
    LAYER M6 ;
      RECT 5230 0 6430 3330 ;
    LAYER M6 ;
      RECT 2500 2730 6430 3930 ;
    LAYER M6 ;
      RECT 3430 0 4630 1530 ;
    LAYER M6 ;
      RECT 2500 930 4630 2130 ;
    LAYER M6 ;
      RECT 10630 0 11830 6930 ;
    LAYER M6 ;
      RECT 10630 6330 18160 7530 ;
    LAYER M6 ;
      RECT 12430 0 13630 5130 ;
    LAYER M6 ;
      RECT 12430 4530 18160 5730 ;
    LAYER M6 ;
      RECT 14230 0 15430 3330 ;
    LAYER M6 ;
      RECT 14230 2730 18160 3930 ;
    LAYER M6 ;
      RECT 16030 0 17230 1530 ;
    LAYER M6 ;
      RECT 16030 930 18160 2130 ;
    LAYER M6 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M6 ;
      RECT 2500 0 18160 430 ;
  END
END C29_1
MACRO C29_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN C29_2 0 0 ;
  SIZE 16470 BY 19420 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6695 18990 9775 19420 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6695 0 9775 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 8530 1660 10890 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 14810 5735 16470 13685 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 11730 13970 19420 ;
    LAYER M8 ;
      RECT 2500 0 13970 7690 ;
    LAYER M8 ;
      RECT 13970 17760 16470 19420 ;
    LAYER M8 ;
      RECT 13970 0 16470 1660 ;
    LAYER M8 ;
      RECT 14810 0 16470 19420 ;
    LAYER M8 ;
      RECT 0 8530 13970 10890 ;
    LAYER M8 ;
      RECT 5000 10890 6740 16920 ;
    LAYER M8 ;
      RECT 5000 10890 6740 16920 ;
    LAYER M8 ;
      RECT 5000 2500 6740 8530 ;
    LAYER M8 ;
      RECT 9730 10890 11470 16920 ;
    LAYER M8 ;
      RECT 9730 10890 11470 16920 ;
    LAYER M8 ;
      RECT 9730 2500 11470 8530 ;
    LAYER M5 ;
      RECT 7635 0 8835 19420 ;
    LAYER M5 ;
      RECT 2500 9110 13970 10310 ;
    LAYER M5 ;
      RECT 9435 11510 10635 19420 ;
    LAYER M5 ;
      RECT 9435 10910 13970 12110 ;
    LAYER M5 ;
      RECT 11235 13310 12435 19420 ;
    LAYER M5 ;
      RECT 11235 12710 13970 13910 ;
    LAYER M5 ;
      RECT 13035 15110 13970 19420 ;
    LAYER M5 ;
      RECT 13035 14510 13970 15710 ;
    LAYER M5 ;
      RECT 5835 11510 7035 19420 ;
    LAYER M5 ;
      RECT 2500 10910 7035 12110 ;
    LAYER M5 ;
      RECT 4035 13310 5235 19420 ;
    LAYER M5 ;
      RECT 2500 12710 5235 13910 ;
    LAYER M5 ;
      RECT 2500 15110 3435 19420 ;
    LAYER M5 ;
      RECT 2500 14510 3435 15710 ;
    LAYER M5 ;
      RECT 5835 0 7035 7910 ;
    LAYER M5 ;
      RECT 2500 7310 7035 8510 ;
    LAYER M5 ;
      RECT 4035 0 5235 6110 ;
    LAYER M5 ;
      RECT 2500 5510 5235 6710 ;
    LAYER M5 ;
      RECT 2500 0 3435 4310 ;
    LAYER M5 ;
      RECT 2500 3710 3435 4910 ;
    LAYER M5 ;
      RECT 9435 0 10635 7910 ;
    LAYER M5 ;
      RECT 9435 7310 13970 8510 ;
    LAYER M5 ;
      RECT 11235 0 12435 6110 ;
    LAYER M5 ;
      RECT 11235 5510 13970 6710 ;
    LAYER M5 ;
      RECT 13035 0 13970 4310 ;
    LAYER M5 ;
      RECT 13035 3710 13970 4910 ;
    LAYER M5 ;
      RECT 2500 18990 13970 19420 ;
    LAYER M5 ;
      RECT 2500 0 13970 430 ;
    LAYER M6 ;
      RECT 8535 10610 9735 19420 ;
    LAYER M6 ;
      RECT 8535 10010 13970 11210 ;
    LAYER M6 ;
      RECT 10335 12410 11535 19420 ;
    LAYER M6 ;
      RECT 10335 11810 13970 13010 ;
    LAYER M6 ;
      RECT 12135 14210 13335 19420 ;
    LAYER M6 ;
      RECT 12135 13610 13970 14810 ;
    LAYER M6 ;
      RECT 6735 10610 7935 19420 ;
    LAYER M6 ;
      RECT 2500 10010 7935 11210 ;
    LAYER M6 ;
      RECT 4935 12410 6135 19420 ;
    LAYER M6 ;
      RECT 2500 11810 6135 13010 ;
    LAYER M6 ;
      RECT 3135 14210 4335 19420 ;
    LAYER M6 ;
      RECT 2500 13610 4335 14810 ;
    LAYER M6 ;
      RECT 6735 0 7935 8810 ;
    LAYER M6 ;
      RECT 2500 8210 7935 9410 ;
    LAYER M6 ;
      RECT 4935 0 6135 7010 ;
    LAYER M6 ;
      RECT 2500 6410 6135 7610 ;
    LAYER M6 ;
      RECT 3135 0 4335 5210 ;
    LAYER M6 ;
      RECT 2500 4610 4335 5810 ;
    LAYER M6 ;
      RECT 8535 0 9735 8810 ;
    LAYER M6 ;
      RECT 8535 8210 13970 9410 ;
    LAYER M6 ;
      RECT 10335 0 11535 7010 ;
    LAYER M6 ;
      RECT 10335 6410 13970 7610 ;
    LAYER M6 ;
      RECT 12135 0 13335 5210 ;
    LAYER M6 ;
      RECT 12135 4610 13970 5810 ;
    LAYER M6 ;
      RECT 2500 18990 13970 19420 ;
    LAYER M6 ;
      RECT 2500 0 13970 430 ;
  END
END C29_2
MACRO C29_3
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN C29_3 0 0 ;
  SIZE 14610 BY 21780 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6075 21350 8535 21780 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6075 0 8535 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 9710 1660 12070 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 12950 7845 14610 13935 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 12910 12110 21780 ;
    LAYER M8 ;
      RECT 2500 0 12110 8870 ;
    LAYER M8 ;
      RECT 12110 20120 14610 21780 ;
    LAYER M8 ;
      RECT 12110 0 14610 1660 ;
    LAYER M8 ;
      RECT 12950 0 14610 21780 ;
    LAYER M8 ;
      RECT 0 9710 12110 12070 ;
    LAYER M8 ;
      RECT 5000 12070 6740 19280 ;
    LAYER M8 ;
      RECT 5000 12070 6740 19280 ;
    LAYER M8 ;
      RECT 5000 2500 6740 9710 ;
    LAYER M8 ;
      RECT 7870 12070 9610 19280 ;
    LAYER M8 ;
      RECT 7870 12070 9610 19280 ;
    LAYER M8 ;
      RECT 7870 2500 9610 9710 ;
    LAYER M5 ;
      RECT 6705 0 7905 21780 ;
    LAYER M5 ;
      RECT 2500 10290 12110 11490 ;
    LAYER M5 ;
      RECT 8505 12690 9705 21780 ;
    LAYER M5 ;
      RECT 8505 12090 12110 13290 ;
    LAYER M5 ;
      RECT 10305 14490 11505 21780 ;
    LAYER M5 ;
      RECT 10305 13890 12110 15090 ;
    LAYER M5 ;
      RECT 12105 16290 12110 21780 ;
    LAYER M5 ;
      RECT 12105 15690 12110 16890 ;
    LAYER M5 ;
      RECT 4905 12690 6105 21780 ;
    LAYER M5 ;
      RECT 2500 12090 6105 13290 ;
    LAYER M5 ;
      RECT 3105 14490 4305 21780 ;
    LAYER M5 ;
      RECT 2500 13890 4305 15090 ;
    LAYER M5 ;
      RECT 2500 16290 2505 21780 ;
    LAYER M5 ;
      RECT 2500 15690 2505 16890 ;
    LAYER M5 ;
      RECT 4905 0 6105 9090 ;
    LAYER M5 ;
      RECT 2500 8490 6105 9690 ;
    LAYER M5 ;
      RECT 3105 0 4305 7290 ;
    LAYER M5 ;
      RECT 2500 6690 4305 7890 ;
    LAYER M5 ;
      RECT 2500 0 2505 5490 ;
    LAYER M5 ;
      RECT 2500 4890 2505 6090 ;
    LAYER M5 ;
      RECT 8505 0 9705 9090 ;
    LAYER M5 ;
      RECT 8505 8490 12110 9690 ;
    LAYER M5 ;
      RECT 10305 0 11505 7290 ;
    LAYER M5 ;
      RECT 10305 6690 12110 7890 ;
    LAYER M5 ;
      RECT 12105 0 12110 5490 ;
    LAYER M5 ;
      RECT 12105 4890 12110 6090 ;
    LAYER M5 ;
      RECT 2500 21350 12110 21780 ;
    LAYER M5 ;
      RECT 2500 0 12110 430 ;
    LAYER M6 ;
      RECT 7605 11790 8805 21780 ;
    LAYER M6 ;
      RECT 7605 11190 12110 12390 ;
    LAYER M6 ;
      RECT 9405 13590 10605 21780 ;
    LAYER M6 ;
      RECT 9405 12990 12110 14190 ;
    LAYER M6 ;
      RECT 11205 15390 12110 21780 ;
    LAYER M6 ;
      RECT 11205 14790 12110 15990 ;
    LAYER M6 ;
      RECT 5805 11790 7005 21780 ;
    LAYER M6 ;
      RECT 2500 11190 7005 12390 ;
    LAYER M6 ;
      RECT 4005 13590 5205 21780 ;
    LAYER M6 ;
      RECT 2500 12990 5205 14190 ;
    LAYER M6 ;
      RECT 2500 15390 3405 21780 ;
    LAYER M6 ;
      RECT 2500 14790 3405 15990 ;
    LAYER M6 ;
      RECT 5805 0 7005 9990 ;
    LAYER M6 ;
      RECT 2500 9390 7005 10590 ;
    LAYER M6 ;
      RECT 4005 0 5205 8190 ;
    LAYER M6 ;
      RECT 2500 7590 5205 8790 ;
    LAYER M6 ;
      RECT 2500 0 3405 6390 ;
    LAYER M6 ;
      RECT 2500 5790 3405 6990 ;
    LAYER M6 ;
      RECT 7605 0 8805 9990 ;
    LAYER M6 ;
      RECT 7605 9390 12110 10590 ;
    LAYER M6 ;
      RECT 9405 0 10605 8190 ;
    LAYER M6 ;
      RECT 9405 7590 12110 8790 ;
    LAYER M6 ;
      RECT 11205 0 12110 6390 ;
    LAYER M6 ;
      RECT 11205 5790 12110 6990 ;
    LAYER M6 ;
      RECT 2500 21350 12110 21780 ;
    LAYER M6 ;
      RECT 2500 0 12110 430 ;
  END
END C29_3
MACRO CSeries_D_1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CSeries_D_1_1 0 0 ;
  SIZE 7040 BY 8480 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 8380 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 5760 3510 7040 4970 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 6920 5360 8380 ;
    LAYER M8 ;
      RECT 0 100 5360 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 6920 ;
    LAYER M8 ;
      RECT 1680 3510 7040 4970 ;
    LAYER M8 ;
      RECT 1820 2540 3280 5940 ;
    LAYER M8 ;
      RECT 3760 2540 5220 5940 ;
  END
END CSeries_D_1_1
MACRO CSeries_D_2_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CSeries_D_2_1 0 0 ;
  SIZE 8150 BY 9590 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 9490 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 6870 4065 8150 5525 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 8030 6470 9490 ;
    LAYER M8 ;
      RECT 0 100 6470 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 8030 ;
    LAYER M8 ;
      RECT 1680 4065 8150 5525 ;
    LAYER M8 ;
      RECT 1820 2540 3280 7050 ;
    LAYER M8 ;
      RECT 4870 2540 6330 7050 ;
  END
END CSeries_D_2_1
MACRO CShunt_D_1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CShunt_D_1_1 0 0 ;
  SIZE 8170 BY 9610 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 9510 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 6890 4075 8170 5535 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 8050 6490 9510 ;
    LAYER M8 ;
      RECT 0 100 6490 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 8050 ;
    LAYER M8 ;
      RECT 1680 4075 8170 5535 ;
    LAYER M8 ;
      RECT 1820 2540 3280 7070 ;
    LAYER M8 ;
      RECT 4890 2540 6350 7070 ;
  END
END CShunt_D_1_1
MACRO CShunt_D_2_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CShunt_D_2_1 0 0 ;
  SIZE 8170 BY 9610 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 9510 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 6890 4075 8170 5535 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 8050 6490 9510 ;
    LAYER M8 ;
      RECT 0 100 6490 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 8050 ;
    LAYER M8 ;
      RECT 1680 4075 8170 5535 ;
    LAYER M8 ;
      RECT 1820 2540 3280 7070 ;
    LAYER M8 ;
      RECT 4890 2540 6350 7070 ;
  END
END CShunt_D_2_1
MACRO Cnew1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN Cnew1_1 0 0 ;
  SIZE 20660 BY 15660 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 15230 12568 15660 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 0 12568 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 6650 1660 9010 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 19000 1760 20660 13900 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 9850 18160 15660 ;
    LAYER M8 ;
      RECT 2500 0 18160 5810 ;
    LAYER M8 ;
      RECT 18160 14000 20660 15660 ;
    LAYER M8 ;
      RECT 18160 0 20660 1660 ;
    LAYER M8 ;
      RECT 19000 0 20660 15660 ;
    LAYER M8 ;
      RECT 0 6650 18160 9010 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 2500 6740 6650 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 2500 9713 6650 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 2500 12687 6650 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 2500 15660 6650 ;
    LAYER M5 ;
      RECT 9730 0 10930 15660 ;
    LAYER M5 ;
      RECT 2500 7230 18160 8430 ;
    LAYER M5 ;
      RECT 11530 9630 12730 15660 ;
    LAYER M5 ;
      RECT 11530 9030 18160 10230 ;
    LAYER M5 ;
      RECT 13330 11430 14530 15660 ;
    LAYER M5 ;
      RECT 13330 10830 18160 12030 ;
    LAYER M5 ;
      RECT 15130 13230 16330 15660 ;
    LAYER M5 ;
      RECT 15130 12630 18160 13830 ;
    LAYER M5 ;
      RECT 16930 15030 18130 15660 ;
    LAYER M5 ;
      RECT 16930 14430 18160 15630 ;
    LAYER M5 ;
      RECT 7930 9630 9130 15660 ;
    LAYER M5 ;
      RECT 2500 9030 9130 10230 ;
    LAYER M5 ;
      RECT 6130 11430 7330 15660 ;
    LAYER M5 ;
      RECT 2500 10830 7330 12030 ;
    LAYER M5 ;
      RECT 4330 13230 5530 15660 ;
    LAYER M5 ;
      RECT 2500 12630 5530 13830 ;
    LAYER M5 ;
      RECT 2530 15030 3730 15660 ;
    LAYER M5 ;
      RECT 2500 14430 3730 15630 ;
    LAYER M5 ;
      RECT 7930 0 9130 6030 ;
    LAYER M5 ;
      RECT 2500 5430 9130 6630 ;
    LAYER M5 ;
      RECT 6130 0 7330 4230 ;
    LAYER M5 ;
      RECT 2500 3630 7330 4830 ;
    LAYER M5 ;
      RECT 4330 0 5530 2430 ;
    LAYER M5 ;
      RECT 2500 1830 5530 3030 ;
    LAYER M5 ;
      RECT 2530 0 3730 630 ;
    LAYER M5 ;
      RECT 2500 30 3730 1230 ;
    LAYER M5 ;
      RECT 11530 0 12730 6030 ;
    LAYER M5 ;
      RECT 11530 5430 18160 6630 ;
    LAYER M5 ;
      RECT 13330 0 14530 4230 ;
    LAYER M5 ;
      RECT 13330 3630 18160 4830 ;
    LAYER M5 ;
      RECT 15130 0 16330 2430 ;
    LAYER M5 ;
      RECT 15130 1830 18160 3030 ;
    LAYER M5 ;
      RECT 16930 0 18130 630 ;
    LAYER M5 ;
      RECT 16930 30 18160 1230 ;
    LAYER M5 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M5 ;
      RECT 2500 0 18160 430 ;
    LAYER M6 ;
      RECT 10630 8730 11830 15660 ;
    LAYER M6 ;
      RECT 10630 8130 18160 9330 ;
    LAYER M6 ;
      RECT 12430 10530 13630 15660 ;
    LAYER M6 ;
      RECT 12430 9930 18160 11130 ;
    LAYER M6 ;
      RECT 14230 12330 15430 15660 ;
    LAYER M6 ;
      RECT 14230 11730 18160 12930 ;
    LAYER M6 ;
      RECT 16030 14130 17230 15660 ;
    LAYER M6 ;
      RECT 16030 13530 18160 14730 ;
    LAYER M6 ;
      RECT 8830 8730 10030 15660 ;
    LAYER M6 ;
      RECT 2500 8130 10030 9330 ;
    LAYER M6 ;
      RECT 7030 10530 8230 15660 ;
    LAYER M6 ;
      RECT 2500 9930 8230 11130 ;
    LAYER M6 ;
      RECT 5230 12330 6430 15660 ;
    LAYER M6 ;
      RECT 2500 11730 6430 12930 ;
    LAYER M6 ;
      RECT 3430 14130 4630 15660 ;
    LAYER M6 ;
      RECT 2500 13530 4630 14730 ;
    LAYER M6 ;
      RECT 8830 0 10030 6930 ;
    LAYER M6 ;
      RECT 2500 6330 10030 7530 ;
    LAYER M6 ;
      RECT 7030 0 8230 5130 ;
    LAYER M6 ;
      RECT 2500 4530 8230 5730 ;
    LAYER M6 ;
      RECT 5230 0 6430 3330 ;
    LAYER M6 ;
      RECT 2500 2730 6430 3930 ;
    LAYER M6 ;
      RECT 3430 0 4630 1530 ;
    LAYER M6 ;
      RECT 2500 930 4630 2130 ;
    LAYER M6 ;
      RECT 10630 0 11830 6930 ;
    LAYER M6 ;
      RECT 10630 6330 18160 7530 ;
    LAYER M6 ;
      RECT 12430 0 13630 5130 ;
    LAYER M6 ;
      RECT 12430 4530 18160 5730 ;
    LAYER M6 ;
      RECT 14230 0 15430 3330 ;
    LAYER M6 ;
      RECT 14230 2730 18160 3930 ;
    LAYER M6 ;
      RECT 16030 0 17230 1530 ;
    LAYER M6 ;
      RECT 16030 930 18160 2130 ;
    LAYER M6 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M6 ;
      RECT 2500 0 18160 430 ;
  END
END Cnew1_1
MACRO Cnew1_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN Cnew1_2 0 0 ;
  SIZE 16470 BY 19420 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6695 18990 9775 19420 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6695 0 9775 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 8530 1660 10890 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 14810 5735 16470 13685 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 11730 13970 19420 ;
    LAYER M8 ;
      RECT 2500 0 13970 7690 ;
    LAYER M8 ;
      RECT 13970 17760 16470 19420 ;
    LAYER M8 ;
      RECT 13970 0 16470 1660 ;
    LAYER M8 ;
      RECT 14810 0 16470 19420 ;
    LAYER M8 ;
      RECT 0 8530 13970 10890 ;
    LAYER M8 ;
      RECT 5000 10890 6740 16920 ;
    LAYER M8 ;
      RECT 5000 10890 6740 16920 ;
    LAYER M8 ;
      RECT 5000 2500 6740 8530 ;
    LAYER M8 ;
      RECT 9730 10890 11470 16920 ;
    LAYER M8 ;
      RECT 9730 10890 11470 16920 ;
    LAYER M8 ;
      RECT 9730 2500 11470 8530 ;
    LAYER M5 ;
      RECT 7635 0 8835 19420 ;
    LAYER M5 ;
      RECT 2500 9110 13970 10310 ;
    LAYER M5 ;
      RECT 9435 11510 10635 19420 ;
    LAYER M5 ;
      RECT 9435 10910 13970 12110 ;
    LAYER M5 ;
      RECT 11235 13310 12435 19420 ;
    LAYER M5 ;
      RECT 11235 12710 13970 13910 ;
    LAYER M5 ;
      RECT 13035 15110 13970 19420 ;
    LAYER M5 ;
      RECT 13035 14510 13970 15710 ;
    LAYER M5 ;
      RECT 5835 11510 7035 19420 ;
    LAYER M5 ;
      RECT 2500 10910 7035 12110 ;
    LAYER M5 ;
      RECT 4035 13310 5235 19420 ;
    LAYER M5 ;
      RECT 2500 12710 5235 13910 ;
    LAYER M5 ;
      RECT 2500 15110 3435 19420 ;
    LAYER M5 ;
      RECT 2500 14510 3435 15710 ;
    LAYER M5 ;
      RECT 5835 0 7035 7910 ;
    LAYER M5 ;
      RECT 2500 7310 7035 8510 ;
    LAYER M5 ;
      RECT 4035 0 5235 6110 ;
    LAYER M5 ;
      RECT 2500 5510 5235 6710 ;
    LAYER M5 ;
      RECT 2500 0 3435 4310 ;
    LAYER M5 ;
      RECT 2500 3710 3435 4910 ;
    LAYER M5 ;
      RECT 9435 0 10635 7910 ;
    LAYER M5 ;
      RECT 9435 7310 13970 8510 ;
    LAYER M5 ;
      RECT 11235 0 12435 6110 ;
    LAYER M5 ;
      RECT 11235 5510 13970 6710 ;
    LAYER M5 ;
      RECT 13035 0 13970 4310 ;
    LAYER M5 ;
      RECT 13035 3710 13970 4910 ;
    LAYER M5 ;
      RECT 2500 18990 13970 19420 ;
    LAYER M5 ;
      RECT 2500 0 13970 430 ;
    LAYER M6 ;
      RECT 8535 10610 9735 19420 ;
    LAYER M6 ;
      RECT 8535 10010 13970 11210 ;
    LAYER M6 ;
      RECT 10335 12410 11535 19420 ;
    LAYER M6 ;
      RECT 10335 11810 13970 13010 ;
    LAYER M6 ;
      RECT 12135 14210 13335 19420 ;
    LAYER M6 ;
      RECT 12135 13610 13970 14810 ;
    LAYER M6 ;
      RECT 6735 10610 7935 19420 ;
    LAYER M6 ;
      RECT 2500 10010 7935 11210 ;
    LAYER M6 ;
      RECT 4935 12410 6135 19420 ;
    LAYER M6 ;
      RECT 2500 11810 6135 13010 ;
    LAYER M6 ;
      RECT 3135 14210 4335 19420 ;
    LAYER M6 ;
      RECT 2500 13610 4335 14810 ;
    LAYER M6 ;
      RECT 6735 0 7935 8810 ;
    LAYER M6 ;
      RECT 2500 8210 7935 9410 ;
    LAYER M6 ;
      RECT 4935 0 6135 7010 ;
    LAYER M6 ;
      RECT 2500 6410 6135 7610 ;
    LAYER M6 ;
      RECT 3135 0 4335 5210 ;
    LAYER M6 ;
      RECT 2500 4610 4335 5810 ;
    LAYER M6 ;
      RECT 8535 0 9735 8810 ;
    LAYER M6 ;
      RECT 8535 8210 13970 9410 ;
    LAYER M6 ;
      RECT 10335 0 11535 7010 ;
    LAYER M6 ;
      RECT 10335 6410 13970 7610 ;
    LAYER M6 ;
      RECT 12135 0 13335 5210 ;
    LAYER M6 ;
      RECT 12135 4610 13970 5810 ;
    LAYER M6 ;
      RECT 2500 18990 13970 19420 ;
    LAYER M6 ;
      RECT 2500 0 13970 430 ;
  END
END Cnew1_2
MACRO Cnew1_3
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN Cnew1_3 0 0 ;
  SIZE 14610 BY 21780 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6075 21350 8535 21780 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6075 0 8535 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 9710 1660 12070 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 12950 7845 14610 13935 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 12910 12110 21780 ;
    LAYER M8 ;
      RECT 2500 0 12110 8870 ;
    LAYER M8 ;
      RECT 12110 20120 14610 21780 ;
    LAYER M8 ;
      RECT 12110 0 14610 1660 ;
    LAYER M8 ;
      RECT 12950 0 14610 21780 ;
    LAYER M8 ;
      RECT 0 9710 12110 12070 ;
    LAYER M8 ;
      RECT 5000 12070 6740 19280 ;
    LAYER M8 ;
      RECT 5000 12070 6740 19280 ;
    LAYER M8 ;
      RECT 5000 2500 6740 9710 ;
    LAYER M8 ;
      RECT 7870 12070 9610 19280 ;
    LAYER M8 ;
      RECT 7870 12070 9610 19280 ;
    LAYER M8 ;
      RECT 7870 2500 9610 9710 ;
    LAYER M5 ;
      RECT 6705 0 7905 21780 ;
    LAYER M5 ;
      RECT 2500 10290 12110 11490 ;
    LAYER M5 ;
      RECT 8505 12690 9705 21780 ;
    LAYER M5 ;
      RECT 8505 12090 12110 13290 ;
    LAYER M5 ;
      RECT 10305 14490 11505 21780 ;
    LAYER M5 ;
      RECT 10305 13890 12110 15090 ;
    LAYER M5 ;
      RECT 12105 16290 12110 21780 ;
    LAYER M5 ;
      RECT 12105 15690 12110 16890 ;
    LAYER M5 ;
      RECT 4905 12690 6105 21780 ;
    LAYER M5 ;
      RECT 2500 12090 6105 13290 ;
    LAYER M5 ;
      RECT 3105 14490 4305 21780 ;
    LAYER M5 ;
      RECT 2500 13890 4305 15090 ;
    LAYER M5 ;
      RECT 2500 16290 2505 21780 ;
    LAYER M5 ;
      RECT 2500 15690 2505 16890 ;
    LAYER M5 ;
      RECT 4905 0 6105 9090 ;
    LAYER M5 ;
      RECT 2500 8490 6105 9690 ;
    LAYER M5 ;
      RECT 3105 0 4305 7290 ;
    LAYER M5 ;
      RECT 2500 6690 4305 7890 ;
    LAYER M5 ;
      RECT 2500 0 2505 5490 ;
    LAYER M5 ;
      RECT 2500 4890 2505 6090 ;
    LAYER M5 ;
      RECT 8505 0 9705 9090 ;
    LAYER M5 ;
      RECT 8505 8490 12110 9690 ;
    LAYER M5 ;
      RECT 10305 0 11505 7290 ;
    LAYER M5 ;
      RECT 10305 6690 12110 7890 ;
    LAYER M5 ;
      RECT 12105 0 12110 5490 ;
    LAYER M5 ;
      RECT 12105 4890 12110 6090 ;
    LAYER M5 ;
      RECT 2500 21350 12110 21780 ;
    LAYER M5 ;
      RECT 2500 0 12110 430 ;
    LAYER M6 ;
      RECT 7605 11790 8805 21780 ;
    LAYER M6 ;
      RECT 7605 11190 12110 12390 ;
    LAYER M6 ;
      RECT 9405 13590 10605 21780 ;
    LAYER M6 ;
      RECT 9405 12990 12110 14190 ;
    LAYER M6 ;
      RECT 11205 15390 12110 21780 ;
    LAYER M6 ;
      RECT 11205 14790 12110 15990 ;
    LAYER M6 ;
      RECT 5805 11790 7005 21780 ;
    LAYER M6 ;
      RECT 2500 11190 7005 12390 ;
    LAYER M6 ;
      RECT 4005 13590 5205 21780 ;
    LAYER M6 ;
      RECT 2500 12990 5205 14190 ;
    LAYER M6 ;
      RECT 2500 15390 3405 21780 ;
    LAYER M6 ;
      RECT 2500 14790 3405 15990 ;
    LAYER M6 ;
      RECT 5805 0 7005 9990 ;
    LAYER M6 ;
      RECT 2500 9390 7005 10590 ;
    LAYER M6 ;
      RECT 4005 0 5205 8190 ;
    LAYER M6 ;
      RECT 2500 7590 5205 8790 ;
    LAYER M6 ;
      RECT 2500 0 3405 6390 ;
    LAYER M6 ;
      RECT 2500 5790 3405 6990 ;
    LAYER M6 ;
      RECT 7605 0 8805 9990 ;
    LAYER M6 ;
      RECT 7605 9390 12110 10590 ;
    LAYER M6 ;
      RECT 9405 0 10605 8190 ;
    LAYER M6 ;
      RECT 9405 7590 12110 8790 ;
    LAYER M6 ;
      RECT 11205 0 12110 6390 ;
    LAYER M6 ;
      RECT 11205 5790 12110 6990 ;
    LAYER M6 ;
      RECT 2500 21350 12110 21780 ;
    LAYER M6 ;
      RECT 2500 0 12110 430 ;
  END
END Cnew1_3
MACRO Cnew2_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN Cnew2_1 0 0 ;
  SIZE 20660 BY 15660 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 15230 12568 15660 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 0 12568 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 6650 1660 9010 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 19000 1760 20660 13900 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 9850 18160 15660 ;
    LAYER M8 ;
      RECT 2500 0 18160 5810 ;
    LAYER M8 ;
      RECT 18160 14000 20660 15660 ;
    LAYER M8 ;
      RECT 18160 0 20660 1660 ;
    LAYER M8 ;
      RECT 19000 0 20660 15660 ;
    LAYER M8 ;
      RECT 0 6650 18160 9010 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 2500 6740 6650 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 2500 9713 6650 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 2500 12687 6650 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 2500 15660 6650 ;
    LAYER M5 ;
      RECT 9730 0 10930 15660 ;
    LAYER M5 ;
      RECT 2500 7230 18160 8430 ;
    LAYER M5 ;
      RECT 11530 9630 12730 15660 ;
    LAYER M5 ;
      RECT 11530 9030 18160 10230 ;
    LAYER M5 ;
      RECT 13330 11430 14530 15660 ;
    LAYER M5 ;
      RECT 13330 10830 18160 12030 ;
    LAYER M5 ;
      RECT 15130 13230 16330 15660 ;
    LAYER M5 ;
      RECT 15130 12630 18160 13830 ;
    LAYER M5 ;
      RECT 16930 15030 18130 15660 ;
    LAYER M5 ;
      RECT 16930 14430 18160 15630 ;
    LAYER M5 ;
      RECT 7930 9630 9130 15660 ;
    LAYER M5 ;
      RECT 2500 9030 9130 10230 ;
    LAYER M5 ;
      RECT 6130 11430 7330 15660 ;
    LAYER M5 ;
      RECT 2500 10830 7330 12030 ;
    LAYER M5 ;
      RECT 4330 13230 5530 15660 ;
    LAYER M5 ;
      RECT 2500 12630 5530 13830 ;
    LAYER M5 ;
      RECT 2530 15030 3730 15660 ;
    LAYER M5 ;
      RECT 2500 14430 3730 15630 ;
    LAYER M5 ;
      RECT 7930 0 9130 6030 ;
    LAYER M5 ;
      RECT 2500 5430 9130 6630 ;
    LAYER M5 ;
      RECT 6130 0 7330 4230 ;
    LAYER M5 ;
      RECT 2500 3630 7330 4830 ;
    LAYER M5 ;
      RECT 4330 0 5530 2430 ;
    LAYER M5 ;
      RECT 2500 1830 5530 3030 ;
    LAYER M5 ;
      RECT 2530 0 3730 630 ;
    LAYER M5 ;
      RECT 2500 30 3730 1230 ;
    LAYER M5 ;
      RECT 11530 0 12730 6030 ;
    LAYER M5 ;
      RECT 11530 5430 18160 6630 ;
    LAYER M5 ;
      RECT 13330 0 14530 4230 ;
    LAYER M5 ;
      RECT 13330 3630 18160 4830 ;
    LAYER M5 ;
      RECT 15130 0 16330 2430 ;
    LAYER M5 ;
      RECT 15130 1830 18160 3030 ;
    LAYER M5 ;
      RECT 16930 0 18130 630 ;
    LAYER M5 ;
      RECT 16930 30 18160 1230 ;
    LAYER M5 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M5 ;
      RECT 2500 0 18160 430 ;
    LAYER M6 ;
      RECT 10630 8730 11830 15660 ;
    LAYER M6 ;
      RECT 10630 8130 18160 9330 ;
    LAYER M6 ;
      RECT 12430 10530 13630 15660 ;
    LAYER M6 ;
      RECT 12430 9930 18160 11130 ;
    LAYER M6 ;
      RECT 14230 12330 15430 15660 ;
    LAYER M6 ;
      RECT 14230 11730 18160 12930 ;
    LAYER M6 ;
      RECT 16030 14130 17230 15660 ;
    LAYER M6 ;
      RECT 16030 13530 18160 14730 ;
    LAYER M6 ;
      RECT 8830 8730 10030 15660 ;
    LAYER M6 ;
      RECT 2500 8130 10030 9330 ;
    LAYER M6 ;
      RECT 7030 10530 8230 15660 ;
    LAYER M6 ;
      RECT 2500 9930 8230 11130 ;
    LAYER M6 ;
      RECT 5230 12330 6430 15660 ;
    LAYER M6 ;
      RECT 2500 11730 6430 12930 ;
    LAYER M6 ;
      RECT 3430 14130 4630 15660 ;
    LAYER M6 ;
      RECT 2500 13530 4630 14730 ;
    LAYER M6 ;
      RECT 8830 0 10030 6930 ;
    LAYER M6 ;
      RECT 2500 6330 10030 7530 ;
    LAYER M6 ;
      RECT 7030 0 8230 5130 ;
    LAYER M6 ;
      RECT 2500 4530 8230 5730 ;
    LAYER M6 ;
      RECT 5230 0 6430 3330 ;
    LAYER M6 ;
      RECT 2500 2730 6430 3930 ;
    LAYER M6 ;
      RECT 3430 0 4630 1530 ;
    LAYER M6 ;
      RECT 2500 930 4630 2130 ;
    LAYER M6 ;
      RECT 10630 0 11830 6930 ;
    LAYER M6 ;
      RECT 10630 6330 18160 7530 ;
    LAYER M6 ;
      RECT 12430 0 13630 5130 ;
    LAYER M6 ;
      RECT 12430 4530 18160 5730 ;
    LAYER M6 ;
      RECT 14230 0 15430 3330 ;
    LAYER M6 ;
      RECT 14230 2730 18160 3930 ;
    LAYER M6 ;
      RECT 16030 0 17230 1530 ;
    LAYER M6 ;
      RECT 16030 930 18160 2130 ;
    LAYER M6 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M6 ;
      RECT 2500 0 18160 430 ;
  END
END Cnew2_1
MACRO Cnew2_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN Cnew2_2 0 0 ;
  SIZE 16470 BY 19420 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6695 18990 9775 19420 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6695 0 9775 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 8530 1660 10890 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 14810 5735 16470 13685 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 11730 13970 19420 ;
    LAYER M8 ;
      RECT 2500 0 13970 7690 ;
    LAYER M8 ;
      RECT 13970 17760 16470 19420 ;
    LAYER M8 ;
      RECT 13970 0 16470 1660 ;
    LAYER M8 ;
      RECT 14810 0 16470 19420 ;
    LAYER M8 ;
      RECT 0 8530 13970 10890 ;
    LAYER M8 ;
      RECT 5000 10890 6740 16920 ;
    LAYER M8 ;
      RECT 5000 10890 6740 16920 ;
    LAYER M8 ;
      RECT 5000 2500 6740 8530 ;
    LAYER M8 ;
      RECT 9730 10890 11470 16920 ;
    LAYER M8 ;
      RECT 9730 10890 11470 16920 ;
    LAYER M8 ;
      RECT 9730 2500 11470 8530 ;
    LAYER M5 ;
      RECT 7635 0 8835 19420 ;
    LAYER M5 ;
      RECT 2500 9110 13970 10310 ;
    LAYER M5 ;
      RECT 9435 11510 10635 19420 ;
    LAYER M5 ;
      RECT 9435 10910 13970 12110 ;
    LAYER M5 ;
      RECT 11235 13310 12435 19420 ;
    LAYER M5 ;
      RECT 11235 12710 13970 13910 ;
    LAYER M5 ;
      RECT 13035 15110 13970 19420 ;
    LAYER M5 ;
      RECT 13035 14510 13970 15710 ;
    LAYER M5 ;
      RECT 5835 11510 7035 19420 ;
    LAYER M5 ;
      RECT 2500 10910 7035 12110 ;
    LAYER M5 ;
      RECT 4035 13310 5235 19420 ;
    LAYER M5 ;
      RECT 2500 12710 5235 13910 ;
    LAYER M5 ;
      RECT 2500 15110 3435 19420 ;
    LAYER M5 ;
      RECT 2500 14510 3435 15710 ;
    LAYER M5 ;
      RECT 5835 0 7035 7910 ;
    LAYER M5 ;
      RECT 2500 7310 7035 8510 ;
    LAYER M5 ;
      RECT 4035 0 5235 6110 ;
    LAYER M5 ;
      RECT 2500 5510 5235 6710 ;
    LAYER M5 ;
      RECT 2500 0 3435 4310 ;
    LAYER M5 ;
      RECT 2500 3710 3435 4910 ;
    LAYER M5 ;
      RECT 9435 0 10635 7910 ;
    LAYER M5 ;
      RECT 9435 7310 13970 8510 ;
    LAYER M5 ;
      RECT 11235 0 12435 6110 ;
    LAYER M5 ;
      RECT 11235 5510 13970 6710 ;
    LAYER M5 ;
      RECT 13035 0 13970 4310 ;
    LAYER M5 ;
      RECT 13035 3710 13970 4910 ;
    LAYER M5 ;
      RECT 2500 18990 13970 19420 ;
    LAYER M5 ;
      RECT 2500 0 13970 430 ;
    LAYER M6 ;
      RECT 8535 10610 9735 19420 ;
    LAYER M6 ;
      RECT 8535 10010 13970 11210 ;
    LAYER M6 ;
      RECT 10335 12410 11535 19420 ;
    LAYER M6 ;
      RECT 10335 11810 13970 13010 ;
    LAYER M6 ;
      RECT 12135 14210 13335 19420 ;
    LAYER M6 ;
      RECT 12135 13610 13970 14810 ;
    LAYER M6 ;
      RECT 6735 10610 7935 19420 ;
    LAYER M6 ;
      RECT 2500 10010 7935 11210 ;
    LAYER M6 ;
      RECT 4935 12410 6135 19420 ;
    LAYER M6 ;
      RECT 2500 11810 6135 13010 ;
    LAYER M6 ;
      RECT 3135 14210 4335 19420 ;
    LAYER M6 ;
      RECT 2500 13610 4335 14810 ;
    LAYER M6 ;
      RECT 6735 0 7935 8810 ;
    LAYER M6 ;
      RECT 2500 8210 7935 9410 ;
    LAYER M6 ;
      RECT 4935 0 6135 7010 ;
    LAYER M6 ;
      RECT 2500 6410 6135 7610 ;
    LAYER M6 ;
      RECT 3135 0 4335 5210 ;
    LAYER M6 ;
      RECT 2500 4610 4335 5810 ;
    LAYER M6 ;
      RECT 8535 0 9735 8810 ;
    LAYER M6 ;
      RECT 8535 8210 13970 9410 ;
    LAYER M6 ;
      RECT 10335 0 11535 7010 ;
    LAYER M6 ;
      RECT 10335 6410 13970 7610 ;
    LAYER M6 ;
      RECT 12135 0 13335 5210 ;
    LAYER M6 ;
      RECT 12135 4610 13970 5810 ;
    LAYER M6 ;
      RECT 2500 18990 13970 19420 ;
    LAYER M6 ;
      RECT 2500 0 13970 430 ;
  END
END Cnew2_2
MACRO Cnew2_3
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN Cnew2_3 0 0 ;
  SIZE 14610 BY 21780 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6075 21350 8535 21780 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6075 0 8535 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 9710 1660 12070 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 12950 7845 14610 13935 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 12910 12110 21780 ;
    LAYER M8 ;
      RECT 2500 0 12110 8870 ;
    LAYER M8 ;
      RECT 12110 20120 14610 21780 ;
    LAYER M8 ;
      RECT 12110 0 14610 1660 ;
    LAYER M8 ;
      RECT 12950 0 14610 21780 ;
    LAYER M8 ;
      RECT 0 9710 12110 12070 ;
    LAYER M8 ;
      RECT 5000 12070 6740 19280 ;
    LAYER M8 ;
      RECT 5000 12070 6740 19280 ;
    LAYER M8 ;
      RECT 5000 2500 6740 9710 ;
    LAYER M8 ;
      RECT 7870 12070 9610 19280 ;
    LAYER M8 ;
      RECT 7870 12070 9610 19280 ;
    LAYER M8 ;
      RECT 7870 2500 9610 9710 ;
    LAYER M5 ;
      RECT 6705 0 7905 21780 ;
    LAYER M5 ;
      RECT 2500 10290 12110 11490 ;
    LAYER M5 ;
      RECT 8505 12690 9705 21780 ;
    LAYER M5 ;
      RECT 8505 12090 12110 13290 ;
    LAYER M5 ;
      RECT 10305 14490 11505 21780 ;
    LAYER M5 ;
      RECT 10305 13890 12110 15090 ;
    LAYER M5 ;
      RECT 12105 16290 12110 21780 ;
    LAYER M5 ;
      RECT 12105 15690 12110 16890 ;
    LAYER M5 ;
      RECT 4905 12690 6105 21780 ;
    LAYER M5 ;
      RECT 2500 12090 6105 13290 ;
    LAYER M5 ;
      RECT 3105 14490 4305 21780 ;
    LAYER M5 ;
      RECT 2500 13890 4305 15090 ;
    LAYER M5 ;
      RECT 2500 16290 2505 21780 ;
    LAYER M5 ;
      RECT 2500 15690 2505 16890 ;
    LAYER M5 ;
      RECT 4905 0 6105 9090 ;
    LAYER M5 ;
      RECT 2500 8490 6105 9690 ;
    LAYER M5 ;
      RECT 3105 0 4305 7290 ;
    LAYER M5 ;
      RECT 2500 6690 4305 7890 ;
    LAYER M5 ;
      RECT 2500 0 2505 5490 ;
    LAYER M5 ;
      RECT 2500 4890 2505 6090 ;
    LAYER M5 ;
      RECT 8505 0 9705 9090 ;
    LAYER M5 ;
      RECT 8505 8490 12110 9690 ;
    LAYER M5 ;
      RECT 10305 0 11505 7290 ;
    LAYER M5 ;
      RECT 10305 6690 12110 7890 ;
    LAYER M5 ;
      RECT 12105 0 12110 5490 ;
    LAYER M5 ;
      RECT 12105 4890 12110 6090 ;
    LAYER M5 ;
      RECT 2500 21350 12110 21780 ;
    LAYER M5 ;
      RECT 2500 0 12110 430 ;
    LAYER M6 ;
      RECT 7605 11790 8805 21780 ;
    LAYER M6 ;
      RECT 7605 11190 12110 12390 ;
    LAYER M6 ;
      RECT 9405 13590 10605 21780 ;
    LAYER M6 ;
      RECT 9405 12990 12110 14190 ;
    LAYER M6 ;
      RECT 11205 15390 12110 21780 ;
    LAYER M6 ;
      RECT 11205 14790 12110 15990 ;
    LAYER M6 ;
      RECT 5805 11790 7005 21780 ;
    LAYER M6 ;
      RECT 2500 11190 7005 12390 ;
    LAYER M6 ;
      RECT 4005 13590 5205 21780 ;
    LAYER M6 ;
      RECT 2500 12990 5205 14190 ;
    LAYER M6 ;
      RECT 2500 15390 3405 21780 ;
    LAYER M6 ;
      RECT 2500 14790 3405 15990 ;
    LAYER M6 ;
      RECT 5805 0 7005 9990 ;
    LAYER M6 ;
      RECT 2500 9390 7005 10590 ;
    LAYER M6 ;
      RECT 4005 0 5205 8190 ;
    LAYER M6 ;
      RECT 2500 7590 5205 8790 ;
    LAYER M6 ;
      RECT 2500 0 3405 6390 ;
    LAYER M6 ;
      RECT 2500 5790 3405 6990 ;
    LAYER M6 ;
      RECT 7605 0 8805 9990 ;
    LAYER M6 ;
      RECT 7605 9390 12110 10590 ;
    LAYER M6 ;
      RECT 9405 0 10605 8190 ;
    LAYER M6 ;
      RECT 9405 7590 12110 8790 ;
    LAYER M6 ;
      RECT 11205 0 12110 6390 ;
    LAYER M6 ;
      RECT 11205 5790 12110 6990 ;
    LAYER M6 ;
      RECT 2500 21350 12110 21780 ;
    LAYER M6 ;
      RECT 2500 0 12110 430 ;
  END
END Cnew2_3
MACRO LD_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_1 0 0 ;
  SIZE 125000 BY 47500 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 7500 27500 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 117500 20000 125000 27500 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 125000 27500 ;
    LAYER M1 ;
      RECT 7500 0 117500 47500 ;
  END
END LD_1
MACRO LD_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_2 0 0 ;
  SIZE 90000 BY 44000 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 4000 24000 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 86000 20000 90000 24000 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 90000 24000 ;
    LAYER M1 ;
      RECT 4000 0 86000 44000 ;
  END
END LD_2
MACRO LIn_1_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_1_x.1 0 0 ;
  SIZE 127712 BY 119214 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 123712 61547 127712 65547 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 123712 53667 127712 57667 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 108712 54607 118712 64607 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 75962 61547 95712 65547 ;
    LAYER M8 ;
      RECT 0 0 119214 119214 ;
    LAYER M9 ;
      RECT 91712 61547 127712 65547 ;
    LAYER M9 ;
      RECT 23502 25467 95712 93747 ;
    LAYER M9 ;
      RECT 91712 53667 127712 57667 ;
    LAYER M9 ;
      RECT 0 0 119214 119214 ;
    LAYER M1 ;
      RECT 0 0 119214 119214 ;
    LAYER M2 ;
      RECT 0 0 119214 119214 ;
    LAYER M3 ;
      RECT 0 0 119214 119214 ;
    LAYER M4 ;
      RECT 0 0 119214 119214 ;
    LAYER M5 ;
      RECT 0 0 119214 119214 ;
    LAYER M6 ;
      RECT 0 0 119214 119214 ;
    LAYER M7 ;
      RECT 0 0 119214 119214 ;
  END
END LIn_1_x.1
MACRO LIn_1_x.75
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_1_x.75 0 0 ;
  SIZE 129482 BY 131232 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 124982 67925 129482 72425 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 58807 0 63307 4500 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 111732 65175 121732 75175 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 85732 67925 104232 72425 ;
    LAYER M8 ;
      RECT 0 9118 122114 131232 ;
    LAYER M9 ;
      RECT 99732 67925 129482 72425 ;
    LAYER M9 ;
      RECT 24882 32250 97232 108100 ;
    LAYER M9 ;
      RECT 58807 0 63307 36750 ;
    LAYER M9 ;
      RECT 0 9118 122114 131232 ;
    LAYER M1 ;
      RECT 0 9118 122114 131232 ;
    LAYER M2 ;
      RECT 0 9118 122114 131232 ;
    LAYER M3 ;
      RECT 0 9118 122114 131232 ;
    LAYER M4 ;
      RECT 0 9118 122114 131232 ;
    LAYER M5 ;
      RECT 0 9118 122114 131232 ;
    LAYER M6 ;
      RECT 0 9118 122114 131232 ;
    LAYER M7 ;
      RECT 0 9118 122114 131232 ;
  END
END LIn_1_x.75
MACRO LIn_2_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_2_x.1 0 0 ;
  SIZE 118528 BY 114236 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 115528 58928 118528 61928 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 115528 52308 118528 55308 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 103528 52118 113528 62118 ;
    END
  END GND
  OBS
    LAYER M9 ;
      RECT 24208 24208 90028 90028 ;
    LAYER M9 ;
      RECT 87028 58928 118528 61928 ;
    LAYER M9 ;
      RECT 87028 52308 118528 55308 ;
    LAYER M9 ;
      RECT 0 0 114236 114236 ;
    LAYER M1 ;
      RECT 0 0 114236 114236 ;
    LAYER M2 ;
      RECT 0 0 114236 114236 ;
    LAYER M3 ;
      RECT 0 0 114236 114236 ;
    LAYER M4 ;
      RECT 0 0 114236 114236 ;
    LAYER M5 ;
      RECT 0 0 114236 114236 ;
    LAYER M6 ;
      RECT 0 0 114236 114236 ;
    LAYER M7 ;
      RECT 0 0 114236 114236 ;
    LAYER M8 ;
      RECT 0 0 114236 114236 ;
  END
END LIn_2_x.1
MACRO R10_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R10_2 0 0 ;
  SIZE 1880 BY 6440 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 6220 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1560 220 1650 6220 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 1680 6220 ;
    LAYER RPO ;
      RECT 540 0 1340 6440 ;
    LAYER M1 ;
      RECT 230 235 320 6205 ;
    LAYER M1 ;
      RECT 1560 235 1650 6205 ;
    LAYER RH ;
      RECT 0 20 1880 6420 ;
  END
END R10_2
MACRO R1_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R1_0 0 0 ;
  SIZE 6050 BY 5140 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4920 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 5730 220 5820 4920 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 5850 4920 ;
    LAYER RPO ;
      RECT 540 0 5510 5140 ;
    LAYER M1 ;
      RECT 230 235 320 4905 ;
    LAYER M1 ;
      RECT 5730 235 5820 4905 ;
    LAYER RH ;
      RECT 0 20 6050 5120 ;
  END
END R1_0
MACRO R1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R1_1 0 0 ;
  SIZE 6250 BY 5330 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 5110 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 5930 220 6020 5110 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 6050 5110 ;
    LAYER RPO ;
      RECT 540 0 5710 5330 ;
    LAYER M1 ;
      RECT 230 235 320 5095 ;
    LAYER M1 ;
      RECT 5930 235 6020 5095 ;
    LAYER RH ;
      RECT 0 20 6250 5310 ;
  END
END R1_1
MACRO R1_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R1_2 0 0 ;
  SIZE 5860 BY 4960 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4740 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 5540 220 5630 4740 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 5660 4740 ;
    LAYER RPO ;
      RECT 540 0 5320 4960 ;
    LAYER M1 ;
      RECT 230 235 320 4725 ;
    LAYER M1 ;
      RECT 5540 235 5630 4725 ;
    LAYER RH ;
      RECT 0 20 5860 4940 ;
  END
END R1_2
MACRO R26_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R26_0 0 0 ;
  SIZE 2280 BY 9510 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 9290 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1960 220 2050 9290 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 2080 9290 ;
    LAYER RPO ;
      RECT 540 0 1740 9510 ;
    LAYER M1 ;
      RECT 230 235 320 9275 ;
    LAYER M1 ;
      RECT 1960 235 2050 9275 ;
    LAYER RH ;
      RECT 0 20 2280 9490 ;
  END
END R26_0
MACRO R26_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R26_1 0 0 ;
  SIZE 2080 BY 8020 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 7800 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1760 220 1850 7800 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 1880 7800 ;
    LAYER RPO ;
      RECT 540 0 1540 8020 ;
    LAYER M1 ;
      RECT 230 235 320 7785 ;
    LAYER M1 ;
      RECT 1760 235 1850 7785 ;
    LAYER RH ;
      RECT 0 20 2080 8000 ;
  END
END R26_1
MACRO R26_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R26_2 0 0 ;
  SIZE 1880 BY 6440 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 6220 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1560 220 1650 6220 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 1680 6220 ;
    LAYER RPO ;
      RECT 540 0 1340 6440 ;
    LAYER M1 ;
      RECT 230 235 320 6205 ;
    LAYER M1 ;
      RECT 1560 235 1650 6205 ;
    LAYER RH ;
      RECT 0 20 1880 6420 ;
  END
END R26_2
MACRO R27_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R27_1 0 0 ;
  SIZE 6250 BY 5330 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 5110 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 5930 220 6020 5110 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 6050 5110 ;
    LAYER RPO ;
      RECT 540 0 5710 5330 ;
    LAYER M1 ;
      RECT 230 235 320 5095 ;
    LAYER M1 ;
      RECT 5930 235 6020 5095 ;
    LAYER RH ;
      RECT 0 20 6250 5310 ;
  END
END R27_1
MACRO R27_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R27_2 0 0 ;
  SIZE 5860 BY 4960 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4740 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 5540 220 5630 4740 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 5660 4740 ;
    LAYER RPO ;
      RECT 540 0 5320 4960 ;
    LAYER M1 ;
      RECT 230 235 320 4725 ;
    LAYER M1 ;
      RECT 5540 235 5630 4725 ;
    LAYER RH ;
      RECT 0 20 5860 4940 ;
  END
END R27_2
MACRO R28_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R28_0 0 0 ;
  SIZE 34480 BY 8860 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 8640 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 34160 220 34250 8640 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 34280 8640 ;
    LAYER RPO ;
      RECT 540 0 33940 8860 ;
    LAYER M1 ;
      RECT 230 235 320 8625 ;
    LAYER M1 ;
      RECT 34160 235 34250 8625 ;
    LAYER RH ;
      RECT 0 20 34480 8840 ;
  END
END R28_0
MACRO R28_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R28_2 0 0 ;
  SIZE 16790 BY 4400 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4180 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 16470 220 16560 4180 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 16590 4180 ;
    LAYER RPO ;
      RECT 540 0 16250 4400 ;
    LAYER M1 ;
      RECT 230 235 320 4165 ;
    LAYER M1 ;
      RECT 16470 235 16560 4165 ;
    LAYER RH ;
      RECT 0 20 16790 4380 ;
  END
END R28_2
MACRO R2_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R2_0 0 0 ;
  SIZE 34480 BY 8860 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 8640 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 34160 220 34250 8640 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 34280 8640 ;
    LAYER RPO ;
      RECT 540 0 33940 8860 ;
    LAYER M1 ;
      RECT 230 235 320 8625 ;
    LAYER M1 ;
      RECT 34160 235 34250 8625 ;
    LAYER RH ;
      RECT 0 20 34480 8840 ;
  END
END R2_0
MACRO R2_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R2_2 0 0 ;
  SIZE 16790 BY 4400 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4180 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 16470 220 16560 4180 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 16590 4180 ;
    LAYER RPO ;
      RECT 540 0 16250 4400 ;
    LAYER M1 ;
      RECT 230 235 320 4165 ;
    LAYER M1 ;
      RECT 16470 235 16560 4165 ;
    LAYER RH ;
      RECT 0 20 16790 4380 ;
  END
END R2_2
MACRO Stage_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN Stage_1 0 0 ;
  SIZE 8865 BY 8530 ;
  PIN SS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M7 ;
        RECT 0 4850 300 5890 ;
    END
  END SS
  PIN GG
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1365 7530 7865 8530 ;
    END
  END GG
  PIN DD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1165 0 8065 1000 ;
    END
  END DD
  PIN G2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 8365 2880 8865 4480 ;
    END
  END G2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 700 4368 910 4578 ;
    END
  END GND
  OBS
    LAYER M6 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M6 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M6 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M6 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M6 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M6 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M6 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M6 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M6 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M6 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M6 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M6 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M6 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M6 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M6 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M6 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M6 ;
      RECT 1365 6530 7865 6890 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M6 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M6 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M6 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M6 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M6 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M6 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M6 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M6 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M6 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M6 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M6 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M6 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M6 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M6 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M6 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M6 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M6 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M6 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M6 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M6 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M6 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M6 ;
      RECT 1165 1470 8065 2000 ;
    LAYER M1 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M1 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M1 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M1 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M1 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M1 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M1 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M1 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M1 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M1 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M1 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M1 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M1 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M1 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M1 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M1 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M1 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M1 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M1 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M1 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M1 ;
      RECT 6485 4850 6665 5890 ;
    LAYER M1 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M1 ;
      RECT 7045 4850 7225 5890 ;
    LAYER M1 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M1 ;
      RECT 7605 4850 7785 5890 ;
    LAYER M1 ;
      RECT 1365 5990 7865 6170 ;
    LAYER M1 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M1 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M1 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M1 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M1 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M1 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M1 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M1 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M1 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M1 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M1 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M1 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M1 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M1 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M1 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M1 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M1 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M1 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M1 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M1 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M1 ;
      RECT 6485 3160 6665 4200 ;
    LAYER M1 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M1 ;
      RECT 7045 3160 7225 4200 ;
    LAYER M1 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M1 ;
      RECT 7605 3160 7785 4200 ;
    LAYER M1 ;
      RECT 1365 4300 7865 4480 ;
    LAYER M1 ;
      RECT 1365 2880 7865 3060 ;
    LAYER M1 ;
      RECT 700 2510 8530 6540 ;
    LAYER M2 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M2 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M2 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M2 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M2 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M2 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M2 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M2 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M2 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M2 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M2 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M2 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M2 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M2 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M2 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M2 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M2 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M2 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M2 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M2 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M2 ;
      RECT 6485 4850 6665 5890 ;
    LAYER M2 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M2 ;
      RECT 7045 4850 7225 5890 ;
    LAYER M2 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M2 ;
      RECT 7605 4850 7785 5890 ;
    LAYER M2 ;
      RECT 1365 5990 7865 6170 ;
    LAYER M2 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M2 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M2 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M2 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M2 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M2 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M2 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M2 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M2 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M2 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M2 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M2 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M2 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M2 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M2 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M2 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M2 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M2 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M2 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M2 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M2 ;
      RECT 6485 3160 6665 4200 ;
    LAYER M2 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M2 ;
      RECT 7045 3160 7225 4200 ;
    LAYER M2 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M2 ;
      RECT 7605 3160 7785 4200 ;
    LAYER M2 ;
      RECT 1365 4300 7865 4480 ;
    LAYER M2 ;
      RECT 1365 2880 7865 3060 ;
    LAYER M3 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M3 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M3 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M3 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M3 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M3 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M3 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M3 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M3 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M3 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M3 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M3 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M3 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M3 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M3 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M3 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M3 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M3 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M3 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M3 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M3 ;
      RECT 6485 4850 6665 5890 ;
    LAYER M3 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M3 ;
      RECT 7045 4850 7225 5890 ;
    LAYER M3 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M3 ;
      RECT 7605 4850 7785 5890 ;
    LAYER M3 ;
      RECT 1365 5990 7865 6170 ;
    LAYER M3 ;
      RECT 1365 6170 7865 6350 ;
    LAYER M3 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M3 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M3 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M3 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M3 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M3 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M3 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M3 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M3 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M3 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M3 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M3 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M3 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M3 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M3 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M3 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M3 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M3 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M3 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M3 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M3 ;
      RECT 6485 3160 6665 4200 ;
    LAYER M3 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M3 ;
      RECT 7045 3160 7225 4200 ;
    LAYER M3 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M3 ;
      RECT 7605 3160 7785 4200 ;
    LAYER M3 ;
      RECT 1365 4300 7865 4480 ;
    LAYER M3 ;
      RECT 7865 4300 8365 4480 ;
    LAYER M3 ;
      RECT 1365 2880 7865 3060 ;
    LAYER M3 ;
      RECT 7865 2880 8365 3060 ;
    LAYER M3 ;
      RECT 8365 2880 8865 4480 ;
    LAYER M4 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M4 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M4 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M4 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M4 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M4 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M4 ;
      RECT 6485 4850 6665 5890 ;
    LAYER M4 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M4 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M4 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M4 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M4 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M4 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M4 ;
      RECT 7045 4850 7225 5890 ;
    LAYER M4 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M4 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M4 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M4 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M4 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M4 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M4 ;
      RECT 7605 4850 7785 5890 ;
    LAYER M4 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M4 ;
      RECT 1365 6170 7865 6530 ;
    LAYER M4 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M4 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M4 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M4 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M4 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M4 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M4 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M4 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M4 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M4 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M4 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M4 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M4 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M4 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M4 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M4 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M4 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M4 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M4 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M4 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M4 ;
      RECT 6485 3160 6665 4200 ;
    LAYER M4 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M4 ;
      RECT 7045 3160 7225 4200 ;
    LAYER M4 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M4 ;
      RECT 7605 3160 7785 4200 ;
    LAYER M5 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M5 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M5 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M5 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M5 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M5 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M5 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M5 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M5 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M5 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M5 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M5 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M5 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M5 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M5 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M5 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M5 ;
      RECT 6485 4850 6665 5890 ;
    LAYER M5 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M5 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M5 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M5 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M5 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M5 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M5 ;
      RECT 7045 4850 7225 5890 ;
    LAYER M5 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M5 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M5 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M5 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M5 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M5 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M5 ;
      RECT 7605 4850 7785 5890 ;
    LAYER M5 ;
      RECT 1365 6350 7865 6710 ;
    LAYER M5 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M5 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M5 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M5 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M5 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M5 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M5 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M5 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M5 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M5 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6485 3160 6665 4200 ;
    LAYER M5 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M5 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M5 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M5 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M5 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M5 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M5 ;
      RECT 7045 3160 7225 4200 ;
    LAYER M5 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M5 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M5 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M5 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M5 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M5 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M5 ;
      RECT 7605 3160 7785 4200 ;
    LAYER M5 ;
      RECT 1165 1470 8065 2000 ;
    LAYER Poly ;
      RECT 1365 4730 1425 5970 ;
    LAYER Poly ;
      RECT 1645 4730 1705 5970 ;
    LAYER Poly ;
      RECT 1925 4730 1985 5970 ;
    LAYER Poly ;
      RECT 2205 4730 2265 5970 ;
    LAYER Poly ;
      RECT 2485 4730 2545 5970 ;
    LAYER Poly ;
      RECT 2765 4730 2825 5970 ;
    LAYER Poly ;
      RECT 3045 4730 3105 5970 ;
    LAYER Poly ;
      RECT 3325 4730 3385 5970 ;
    LAYER Poly ;
      RECT 3605 4730 3665 5970 ;
    LAYER Poly ;
      RECT 3885 4730 3945 5970 ;
    LAYER Poly ;
      RECT 4165 4730 4225 5970 ;
    LAYER Poly ;
      RECT 4445 4730 4505 5970 ;
    LAYER Poly ;
      RECT 4725 4730 4785 5970 ;
    LAYER Poly ;
      RECT 5005 4730 5065 5970 ;
    LAYER Poly ;
      RECT 5285 4730 5345 5970 ;
    LAYER Poly ;
      RECT 5565 4730 5625 5970 ;
    LAYER Poly ;
      RECT 5845 4730 5905 5970 ;
    LAYER Poly ;
      RECT 6125 4730 6185 5970 ;
    LAYER Poly ;
      RECT 6405 4730 6465 5970 ;
    LAYER Poly ;
      RECT 6685 4730 6745 5970 ;
    LAYER Poly ;
      RECT 6965 4730 7025 5970 ;
    LAYER Poly ;
      RECT 7245 4730 7305 5970 ;
    LAYER Poly ;
      RECT 7525 4730 7585 5970 ;
    LAYER Poly ;
      RECT 7805 4730 7865 5970 ;
    LAYER Poly ;
      RECT 1365 5970 7865 6180 ;
    LAYER Poly ;
      RECT 1365 3080 1425 4280 ;
    LAYER Poly ;
      RECT 1645 3080 1705 4280 ;
    LAYER Poly ;
      RECT 1925 3080 1985 4280 ;
    LAYER Poly ;
      RECT 2205 3080 2265 4280 ;
    LAYER Poly ;
      RECT 2485 3080 2545 4280 ;
    LAYER Poly ;
      RECT 2765 3080 2825 4280 ;
    LAYER Poly ;
      RECT 3045 3080 3105 4280 ;
    LAYER Poly ;
      RECT 3325 3080 3385 4280 ;
    LAYER Poly ;
      RECT 3605 3080 3665 4280 ;
    LAYER Poly ;
      RECT 3885 3080 3945 4280 ;
    LAYER Poly ;
      RECT 4165 3080 4225 4280 ;
    LAYER Poly ;
      RECT 4445 3080 4505 4280 ;
    LAYER Poly ;
      RECT 4725 3080 4785 4280 ;
    LAYER Poly ;
      RECT 5005 3080 5065 4280 ;
    LAYER Poly ;
      RECT 5285 3080 5345 4280 ;
    LAYER Poly ;
      RECT 5565 3080 5625 4280 ;
    LAYER Poly ;
      RECT 5845 3080 5905 4280 ;
    LAYER Poly ;
      RECT 6125 3080 6185 4280 ;
    LAYER Poly ;
      RECT 6405 3080 6465 4280 ;
    LAYER Poly ;
      RECT 6685 3080 6745 4280 ;
    LAYER Poly ;
      RECT 6965 3080 7025 4280 ;
    LAYER Poly ;
      RECT 7245 3080 7305 4280 ;
    LAYER Poly ;
      RECT 7525 3080 7585 4280 ;
    LAYER Poly ;
      RECT 7805 3080 7865 4280 ;
    LAYER Poly ;
      RECT 1365 4280 7865 4490 ;
    LAYER Poly ;
      RECT 1365 2870 7865 3080 ;
    LAYER M7 ;
      RECT 0 4850 8065 5890 ;
    LAYER M7 ;
      RECT 1365 6710 7865 7410 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M7 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M7 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M7 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M7 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M7 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M7 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M7 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M7 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M7 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M7 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M7 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M7 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M7 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M7 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M7 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M7 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M7 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M7 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M7 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M7 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M7 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M7 ;
      RECT 1165 1470 8065 2000 ;
    LAYER M8 ;
      RECT 1365 6710 7865 7750 ;
    LAYER M8 ;
      RECT 1165 760 8065 2000 ;
    LAYER M9 ;
      RECT 1365 6530 7865 8530 ;
    LAYER M9 ;
      RECT 1165 0 8065 2000 ;
  END
END Stage_1
MACRO Stage_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN Stage_2 0 0 ;
  SIZE 15025 BY 8530 ;
  PIN SS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M7 ;
        RECT 0 4850 300 5890 ;
    END
  END SS
  PIN GG
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1365 7530 14025 8530 ;
    END
  END GG
  PIN DD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1165 0 14225 1000 ;
    END
  END DD
  PIN G2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 14525 2880 15025 4480 ;
    END
  END G2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 700 4368 910 4578 ;
    END
  END GND
  OBS
    LAYER M6 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M6 ;
      RECT 14045 4850 14225 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M6 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M6 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M6 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M6 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M6 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M6 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M6 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M6 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M6 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M6 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M6 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M6 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M6 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M6 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M6 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M6 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M6 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M6 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M6 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M6 ;
      RECT 8445 4850 8625 5890 ;
    LAYER M6 ;
      RECT 8445 4850 8625 5890 ;
    LAYER M6 ;
      RECT 8445 4850 8625 5890 ;
    LAYER M6 ;
      RECT 8445 4850 8625 5890 ;
    LAYER M6 ;
      RECT 8445 4850 8625 5890 ;
    LAYER M6 ;
      RECT 9005 4850 9185 5890 ;
    LAYER M6 ;
      RECT 9005 4850 9185 5890 ;
    LAYER M6 ;
      RECT 9005 4850 9185 5890 ;
    LAYER M6 ;
      RECT 9005 4850 9185 5890 ;
    LAYER M6 ;
      RECT 9005 4850 9185 5890 ;
    LAYER M6 ;
      RECT 9565 4850 9745 5890 ;
    LAYER M6 ;
      RECT 9565 4850 9745 5890 ;
    LAYER M6 ;
      RECT 9565 4850 9745 5890 ;
    LAYER M6 ;
      RECT 9565 4850 9745 5890 ;
    LAYER M6 ;
      RECT 9565 4850 9745 5890 ;
    LAYER M6 ;
      RECT 10125 4850 10305 5890 ;
    LAYER M6 ;
      RECT 10125 4850 10305 5890 ;
    LAYER M6 ;
      RECT 10125 4850 10305 5890 ;
    LAYER M6 ;
      RECT 10125 4850 10305 5890 ;
    LAYER M6 ;
      RECT 10125 4850 10305 5890 ;
    LAYER M6 ;
      RECT 10685 4850 10865 5890 ;
    LAYER M6 ;
      RECT 10685 4850 10865 5890 ;
    LAYER M6 ;
      RECT 10685 4850 10865 5890 ;
    LAYER M6 ;
      RECT 10685 4850 10865 5890 ;
    LAYER M6 ;
      RECT 10685 4850 10865 5890 ;
    LAYER M6 ;
      RECT 11245 4850 11425 5890 ;
    LAYER M6 ;
      RECT 11245 4850 11425 5890 ;
    LAYER M6 ;
      RECT 11245 4850 11425 5890 ;
    LAYER M6 ;
      RECT 11245 4850 11425 5890 ;
    LAYER M6 ;
      RECT 11245 4850 11425 5890 ;
    LAYER M6 ;
      RECT 11805 4850 11985 5890 ;
    LAYER M6 ;
      RECT 11805 4850 11985 5890 ;
    LAYER M6 ;
      RECT 11805 4850 11985 5890 ;
    LAYER M6 ;
      RECT 11805 4850 11985 5890 ;
    LAYER M6 ;
      RECT 11805 4850 11985 5890 ;
    LAYER M6 ;
      RECT 12365 4850 12545 5890 ;
    LAYER M6 ;
      RECT 12365 4850 12545 5890 ;
    LAYER M6 ;
      RECT 12365 4850 12545 5890 ;
    LAYER M6 ;
      RECT 12365 4850 12545 5890 ;
    LAYER M6 ;
      RECT 12365 4850 12545 5890 ;
    LAYER M6 ;
      RECT 12925 4850 13105 5890 ;
    LAYER M6 ;
      RECT 12925 4850 13105 5890 ;
    LAYER M6 ;
      RECT 12925 4850 13105 5890 ;
    LAYER M6 ;
      RECT 12925 4850 13105 5890 ;
    LAYER M6 ;
      RECT 12925 4850 13105 5890 ;
    LAYER M6 ;
      RECT 13485 4850 13665 5890 ;
    LAYER M6 ;
      RECT 13485 4850 13665 5890 ;
    LAYER M6 ;
      RECT 13485 4850 13665 5890 ;
    LAYER M6 ;
      RECT 13485 4850 13665 5890 ;
    LAYER M6 ;
      RECT 13485 4850 13665 5890 ;
    LAYER M6 ;
      RECT 1365 6530 14025 6890 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M6 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M6 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M6 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M6 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M6 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M6 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M6 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M6 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M6 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M6 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M6 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M6 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M6 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M6 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M6 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M6 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M6 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M6 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M6 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M6 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M6 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M6 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M6 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M6 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M6 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M6 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M6 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M6 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M6 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M6 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M6 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M6 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M6 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M6 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M6 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M6 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M6 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M6 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M6 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M6 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M6 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M6 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M6 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M6 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M6 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M6 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M6 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M6 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M6 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M6 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M6 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M6 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M6 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M6 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M6 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M6 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M6 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M6 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M6 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M6 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M6 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M6 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M6 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M6 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M6 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M6 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M6 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M6 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M6 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M6 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M6 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M6 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M6 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M6 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M6 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M6 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M6 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M6 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M6 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M6 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M6 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M6 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M6 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M6 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M6 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M6 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M6 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M6 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M6 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M6 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M6 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M6 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M6 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M6 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M6 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M6 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M6 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M6 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M6 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M6 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M6 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M6 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M6 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M6 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M6 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M6 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M6 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M6 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M6 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M6 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M6 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M6 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M6 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M6 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M6 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M6 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M6 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M6 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M6 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M6 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M6 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M6 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M6 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M6 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M6 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M6 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M6 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M6 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M6 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M6 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M6 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M6 ;
      RECT 1165 1470 14225 2000 ;
    LAYER M1 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M1 ;
      RECT 14045 4850 14225 5890 ;
    LAYER M1 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M1 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M1 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M1 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M1 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M1 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M1 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M1 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M1 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M1 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M1 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M1 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M1 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M1 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M1 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M1 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M1 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M1 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M1 ;
      RECT 6485 4850 6665 5890 ;
    LAYER M1 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M1 ;
      RECT 7045 4850 7225 5890 ;
    LAYER M1 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M1 ;
      RECT 7605 4850 7785 5890 ;
    LAYER M1 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M1 ;
      RECT 8165 4850 8345 5890 ;
    LAYER M1 ;
      RECT 8445 4850 8625 5890 ;
    LAYER M1 ;
      RECT 8725 4850 8905 5890 ;
    LAYER M1 ;
      RECT 9005 4850 9185 5890 ;
    LAYER M1 ;
      RECT 9285 4850 9465 5890 ;
    LAYER M1 ;
      RECT 9565 4850 9745 5890 ;
    LAYER M1 ;
      RECT 9845 4850 10025 5890 ;
    LAYER M1 ;
      RECT 10125 4850 10305 5890 ;
    LAYER M1 ;
      RECT 10405 4850 10585 5890 ;
    LAYER M1 ;
      RECT 10685 4850 10865 5890 ;
    LAYER M1 ;
      RECT 10965 4850 11145 5890 ;
    LAYER M1 ;
      RECT 11245 4850 11425 5890 ;
    LAYER M1 ;
      RECT 11525 4850 11705 5890 ;
    LAYER M1 ;
      RECT 11805 4850 11985 5890 ;
    LAYER M1 ;
      RECT 12085 4850 12265 5890 ;
    LAYER M1 ;
      RECT 12365 4850 12545 5890 ;
    LAYER M1 ;
      RECT 12645 4850 12825 5890 ;
    LAYER M1 ;
      RECT 12925 4850 13105 5890 ;
    LAYER M1 ;
      RECT 13205 4850 13385 5890 ;
    LAYER M1 ;
      RECT 13485 4850 13665 5890 ;
    LAYER M1 ;
      RECT 13765 4850 13945 5890 ;
    LAYER M1 ;
      RECT 1365 5990 14025 6170 ;
    LAYER M1 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M1 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M1 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M1 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M1 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M1 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M1 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M1 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M1 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M1 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M1 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M1 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M1 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M1 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M1 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M1 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M1 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M1 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M1 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M1 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M1 ;
      RECT 6485 3160 6665 4200 ;
    LAYER M1 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M1 ;
      RECT 7045 3160 7225 4200 ;
    LAYER M1 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M1 ;
      RECT 7605 3160 7785 4200 ;
    LAYER M1 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M1 ;
      RECT 8165 3160 8345 4200 ;
    LAYER M1 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M1 ;
      RECT 8725 3160 8905 4200 ;
    LAYER M1 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M1 ;
      RECT 9285 3160 9465 4200 ;
    LAYER M1 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M1 ;
      RECT 9845 3160 10025 4200 ;
    LAYER M1 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M1 ;
      RECT 10405 3160 10585 4200 ;
    LAYER M1 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M1 ;
      RECT 10965 3160 11145 4200 ;
    LAYER M1 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M1 ;
      RECT 11525 3160 11705 4200 ;
    LAYER M1 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M1 ;
      RECT 12085 3160 12265 4200 ;
    LAYER M1 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M1 ;
      RECT 12645 3160 12825 4200 ;
    LAYER M1 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M1 ;
      RECT 13205 3160 13385 4200 ;
    LAYER M1 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M1 ;
      RECT 13765 3160 13945 4200 ;
    LAYER M1 ;
      RECT 1365 4300 14025 4480 ;
    LAYER M1 ;
      RECT 1365 2880 14025 3060 ;
    LAYER M1 ;
      RECT 700 2510 14690 6540 ;
    LAYER M2 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M2 ;
      RECT 14045 4850 14225 5890 ;
    LAYER M2 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M2 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M2 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M2 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M2 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M2 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M2 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M2 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M2 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M2 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M2 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M2 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M2 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M2 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M2 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M2 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M2 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M2 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M2 ;
      RECT 6485 4850 6665 5890 ;
    LAYER M2 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M2 ;
      RECT 7045 4850 7225 5890 ;
    LAYER M2 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M2 ;
      RECT 7605 4850 7785 5890 ;
    LAYER M2 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M2 ;
      RECT 8165 4850 8345 5890 ;
    LAYER M2 ;
      RECT 8445 4850 8625 5890 ;
    LAYER M2 ;
      RECT 8725 4850 8905 5890 ;
    LAYER M2 ;
      RECT 9005 4850 9185 5890 ;
    LAYER M2 ;
      RECT 9285 4850 9465 5890 ;
    LAYER M2 ;
      RECT 9565 4850 9745 5890 ;
    LAYER M2 ;
      RECT 9845 4850 10025 5890 ;
    LAYER M2 ;
      RECT 10125 4850 10305 5890 ;
    LAYER M2 ;
      RECT 10405 4850 10585 5890 ;
    LAYER M2 ;
      RECT 10685 4850 10865 5890 ;
    LAYER M2 ;
      RECT 10965 4850 11145 5890 ;
    LAYER M2 ;
      RECT 11245 4850 11425 5890 ;
    LAYER M2 ;
      RECT 11525 4850 11705 5890 ;
    LAYER M2 ;
      RECT 11805 4850 11985 5890 ;
    LAYER M2 ;
      RECT 12085 4850 12265 5890 ;
    LAYER M2 ;
      RECT 12365 4850 12545 5890 ;
    LAYER M2 ;
      RECT 12645 4850 12825 5890 ;
    LAYER M2 ;
      RECT 12925 4850 13105 5890 ;
    LAYER M2 ;
      RECT 13205 4850 13385 5890 ;
    LAYER M2 ;
      RECT 13485 4850 13665 5890 ;
    LAYER M2 ;
      RECT 13765 4850 13945 5890 ;
    LAYER M2 ;
      RECT 1365 5990 14025 6170 ;
    LAYER M2 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M2 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M2 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M2 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M2 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M2 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M2 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M2 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M2 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M2 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M2 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M2 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M2 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M2 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M2 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M2 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M2 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M2 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M2 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M2 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M2 ;
      RECT 6485 3160 6665 4200 ;
    LAYER M2 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M2 ;
      RECT 7045 3160 7225 4200 ;
    LAYER M2 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M2 ;
      RECT 7605 3160 7785 4200 ;
    LAYER M2 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M2 ;
      RECT 8165 3160 8345 4200 ;
    LAYER M2 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M2 ;
      RECT 8725 3160 8905 4200 ;
    LAYER M2 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M2 ;
      RECT 9285 3160 9465 4200 ;
    LAYER M2 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M2 ;
      RECT 9845 3160 10025 4200 ;
    LAYER M2 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M2 ;
      RECT 10405 3160 10585 4200 ;
    LAYER M2 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M2 ;
      RECT 10965 3160 11145 4200 ;
    LAYER M2 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M2 ;
      RECT 11525 3160 11705 4200 ;
    LAYER M2 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M2 ;
      RECT 12085 3160 12265 4200 ;
    LAYER M2 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M2 ;
      RECT 12645 3160 12825 4200 ;
    LAYER M2 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M2 ;
      RECT 13205 3160 13385 4200 ;
    LAYER M2 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M2 ;
      RECT 13765 3160 13945 4200 ;
    LAYER M2 ;
      RECT 1365 4300 14025 4480 ;
    LAYER M2 ;
      RECT 1365 2880 14025 3060 ;
    LAYER M3 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M3 ;
      RECT 14045 4850 14225 5890 ;
    LAYER M3 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M3 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M3 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M3 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M3 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M3 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M3 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M3 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M3 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M3 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M3 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M3 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M3 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M3 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M3 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M3 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M3 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M3 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M3 ;
      RECT 6485 4850 6665 5890 ;
    LAYER M3 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M3 ;
      RECT 7045 4850 7225 5890 ;
    LAYER M3 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M3 ;
      RECT 7605 4850 7785 5890 ;
    LAYER M3 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M3 ;
      RECT 8165 4850 8345 5890 ;
    LAYER M3 ;
      RECT 8445 4850 8625 5890 ;
    LAYER M3 ;
      RECT 8725 4850 8905 5890 ;
    LAYER M3 ;
      RECT 9005 4850 9185 5890 ;
    LAYER M3 ;
      RECT 9285 4850 9465 5890 ;
    LAYER M3 ;
      RECT 9565 4850 9745 5890 ;
    LAYER M3 ;
      RECT 9845 4850 10025 5890 ;
    LAYER M3 ;
      RECT 10125 4850 10305 5890 ;
    LAYER M3 ;
      RECT 10405 4850 10585 5890 ;
    LAYER M3 ;
      RECT 10685 4850 10865 5890 ;
    LAYER M3 ;
      RECT 10965 4850 11145 5890 ;
    LAYER M3 ;
      RECT 11245 4850 11425 5890 ;
    LAYER M3 ;
      RECT 11525 4850 11705 5890 ;
    LAYER M3 ;
      RECT 11805 4850 11985 5890 ;
    LAYER M3 ;
      RECT 12085 4850 12265 5890 ;
    LAYER M3 ;
      RECT 12365 4850 12545 5890 ;
    LAYER M3 ;
      RECT 12645 4850 12825 5890 ;
    LAYER M3 ;
      RECT 12925 4850 13105 5890 ;
    LAYER M3 ;
      RECT 13205 4850 13385 5890 ;
    LAYER M3 ;
      RECT 13485 4850 13665 5890 ;
    LAYER M3 ;
      RECT 13765 4850 13945 5890 ;
    LAYER M3 ;
      RECT 1365 5990 14025 6170 ;
    LAYER M3 ;
      RECT 1365 6170 14025 6350 ;
    LAYER M3 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M3 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M3 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M3 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M3 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M3 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M3 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M3 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M3 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M3 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M3 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M3 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M3 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M3 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M3 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M3 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M3 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M3 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M3 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M3 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M3 ;
      RECT 6485 3160 6665 4200 ;
    LAYER M3 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M3 ;
      RECT 7045 3160 7225 4200 ;
    LAYER M3 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M3 ;
      RECT 7605 3160 7785 4200 ;
    LAYER M3 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M3 ;
      RECT 8165 3160 8345 4200 ;
    LAYER M3 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M3 ;
      RECT 8725 3160 8905 4200 ;
    LAYER M3 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M3 ;
      RECT 9285 3160 9465 4200 ;
    LAYER M3 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M3 ;
      RECT 9845 3160 10025 4200 ;
    LAYER M3 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M3 ;
      RECT 10405 3160 10585 4200 ;
    LAYER M3 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M3 ;
      RECT 10965 3160 11145 4200 ;
    LAYER M3 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M3 ;
      RECT 11525 3160 11705 4200 ;
    LAYER M3 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M3 ;
      RECT 12085 3160 12265 4200 ;
    LAYER M3 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M3 ;
      RECT 12645 3160 12825 4200 ;
    LAYER M3 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M3 ;
      RECT 13205 3160 13385 4200 ;
    LAYER M3 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M3 ;
      RECT 13765 3160 13945 4200 ;
    LAYER M3 ;
      RECT 1365 4300 14025 4480 ;
    LAYER M3 ;
      RECT 14025 4300 14525 4480 ;
    LAYER M3 ;
      RECT 1365 2880 14025 3060 ;
    LAYER M3 ;
      RECT 14025 2880 14525 3060 ;
    LAYER M3 ;
      RECT 14525 2880 15025 4480 ;
    LAYER M4 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M4 ;
      RECT 14045 4850 14225 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M4 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M4 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M4 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M4 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M4 ;
      RECT 6485 4850 6665 5890 ;
    LAYER M4 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M4 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M4 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M4 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M4 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M4 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M4 ;
      RECT 7045 4850 7225 5890 ;
    LAYER M4 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M4 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M4 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M4 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M4 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M4 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M4 ;
      RECT 7605 4850 7785 5890 ;
    LAYER M4 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M4 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M4 ;
      RECT 8165 4200 8345 4850 ;
    LAYER M4 ;
      RECT 8165 4200 8345 4850 ;
    LAYER M4 ;
      RECT 8165 4200 8345 4850 ;
    LAYER M4 ;
      RECT 8165 4200 8345 4850 ;
    LAYER M4 ;
      RECT 8165 4850 8345 5890 ;
    LAYER M4 ;
      RECT 8165 4200 8345 4850 ;
    LAYER M4 ;
      RECT 8445 4850 8625 5890 ;
    LAYER M4 ;
      RECT 8725 4200 8905 4850 ;
    LAYER M4 ;
      RECT 8725 4200 8905 4850 ;
    LAYER M4 ;
      RECT 8725 4200 8905 4850 ;
    LAYER M4 ;
      RECT 8725 4200 8905 4850 ;
    LAYER M4 ;
      RECT 8725 4850 8905 5890 ;
    LAYER M4 ;
      RECT 8725 4200 8905 4850 ;
    LAYER M4 ;
      RECT 9005 4850 9185 5890 ;
    LAYER M4 ;
      RECT 9285 4200 9465 4850 ;
    LAYER M4 ;
      RECT 9285 4200 9465 4850 ;
    LAYER M4 ;
      RECT 9285 4200 9465 4850 ;
    LAYER M4 ;
      RECT 9285 4200 9465 4850 ;
    LAYER M4 ;
      RECT 9285 4850 9465 5890 ;
    LAYER M4 ;
      RECT 9285 4200 9465 4850 ;
    LAYER M4 ;
      RECT 9565 4850 9745 5890 ;
    LAYER M4 ;
      RECT 9845 4200 10025 4850 ;
    LAYER M4 ;
      RECT 9845 4200 10025 4850 ;
    LAYER M4 ;
      RECT 9845 4200 10025 4850 ;
    LAYER M4 ;
      RECT 9845 4200 10025 4850 ;
    LAYER M4 ;
      RECT 9845 4850 10025 5890 ;
    LAYER M4 ;
      RECT 9845 4200 10025 4850 ;
    LAYER M4 ;
      RECT 10125 4850 10305 5890 ;
    LAYER M4 ;
      RECT 10405 4200 10585 4850 ;
    LAYER M4 ;
      RECT 10405 4200 10585 4850 ;
    LAYER M4 ;
      RECT 10405 4200 10585 4850 ;
    LAYER M4 ;
      RECT 10405 4200 10585 4850 ;
    LAYER M4 ;
      RECT 10405 4850 10585 5890 ;
    LAYER M4 ;
      RECT 10405 4200 10585 4850 ;
    LAYER M4 ;
      RECT 10685 4850 10865 5890 ;
    LAYER M4 ;
      RECT 10965 4200 11145 4850 ;
    LAYER M4 ;
      RECT 10965 4200 11145 4850 ;
    LAYER M4 ;
      RECT 10965 4200 11145 4850 ;
    LAYER M4 ;
      RECT 10965 4200 11145 4850 ;
    LAYER M4 ;
      RECT 10965 4850 11145 5890 ;
    LAYER M4 ;
      RECT 10965 4200 11145 4850 ;
    LAYER M4 ;
      RECT 11245 4850 11425 5890 ;
    LAYER M4 ;
      RECT 11525 4200 11705 4850 ;
    LAYER M4 ;
      RECT 11525 4200 11705 4850 ;
    LAYER M4 ;
      RECT 11525 4200 11705 4850 ;
    LAYER M4 ;
      RECT 11525 4200 11705 4850 ;
    LAYER M4 ;
      RECT 11525 4850 11705 5890 ;
    LAYER M4 ;
      RECT 11525 4200 11705 4850 ;
    LAYER M4 ;
      RECT 11805 4850 11985 5890 ;
    LAYER M4 ;
      RECT 12085 4200 12265 4850 ;
    LAYER M4 ;
      RECT 12085 4200 12265 4850 ;
    LAYER M4 ;
      RECT 12085 4200 12265 4850 ;
    LAYER M4 ;
      RECT 12085 4200 12265 4850 ;
    LAYER M4 ;
      RECT 12085 4850 12265 5890 ;
    LAYER M4 ;
      RECT 12085 4200 12265 4850 ;
    LAYER M4 ;
      RECT 12365 4850 12545 5890 ;
    LAYER M4 ;
      RECT 12645 4200 12825 4850 ;
    LAYER M4 ;
      RECT 12645 4200 12825 4850 ;
    LAYER M4 ;
      RECT 12645 4200 12825 4850 ;
    LAYER M4 ;
      RECT 12645 4200 12825 4850 ;
    LAYER M4 ;
      RECT 12645 4850 12825 5890 ;
    LAYER M4 ;
      RECT 12645 4200 12825 4850 ;
    LAYER M4 ;
      RECT 12925 4850 13105 5890 ;
    LAYER M4 ;
      RECT 13205 4200 13385 4850 ;
    LAYER M4 ;
      RECT 13205 4200 13385 4850 ;
    LAYER M4 ;
      RECT 13205 4200 13385 4850 ;
    LAYER M4 ;
      RECT 13205 4200 13385 4850 ;
    LAYER M4 ;
      RECT 13205 4850 13385 5890 ;
    LAYER M4 ;
      RECT 13205 4200 13385 4850 ;
    LAYER M4 ;
      RECT 13485 4850 13665 5890 ;
    LAYER M4 ;
      RECT 13765 4200 13945 4850 ;
    LAYER M4 ;
      RECT 13765 4200 13945 4850 ;
    LAYER M4 ;
      RECT 13765 4200 13945 4850 ;
    LAYER M4 ;
      RECT 13765 4200 13945 4850 ;
    LAYER M4 ;
      RECT 13765 4850 13945 5890 ;
    LAYER M4 ;
      RECT 13765 4200 13945 4850 ;
    LAYER M4 ;
      RECT 1365 6170 14025 6530 ;
    LAYER M4 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M4 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M4 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M4 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M4 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M4 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M4 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M4 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M4 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M4 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M4 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M4 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M4 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M4 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M4 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M4 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M4 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M4 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M4 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M4 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M4 ;
      RECT 6485 3160 6665 4200 ;
    LAYER M4 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M4 ;
      RECT 7045 3160 7225 4200 ;
    LAYER M4 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M4 ;
      RECT 7605 3160 7785 4200 ;
    LAYER M4 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M4 ;
      RECT 8165 3160 8345 4200 ;
    LAYER M4 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M4 ;
      RECT 8725 3160 8905 4200 ;
    LAYER M4 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M4 ;
      RECT 9285 3160 9465 4200 ;
    LAYER M4 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M4 ;
      RECT 9845 3160 10025 4200 ;
    LAYER M4 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M4 ;
      RECT 10405 3160 10585 4200 ;
    LAYER M4 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M4 ;
      RECT 10965 3160 11145 4200 ;
    LAYER M4 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M4 ;
      RECT 11525 3160 11705 4200 ;
    LAYER M4 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M4 ;
      RECT 12085 3160 12265 4200 ;
    LAYER M4 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M4 ;
      RECT 12645 3160 12825 4200 ;
    LAYER M4 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M4 ;
      RECT 13205 3160 13385 4200 ;
    LAYER M4 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M4 ;
      RECT 13765 3160 13945 4200 ;
    LAYER M5 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M5 ;
      RECT 14045 4850 14225 5890 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M5 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M5 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M5 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M5 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M5 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M5 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M5 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M5 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M5 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M5 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M5 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M5 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M5 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M5 ;
      RECT 6485 4200 6665 4850 ;
    LAYER M5 ;
      RECT 6485 4850 6665 5890 ;
    LAYER M5 ;
      RECT 6765 4850 6945 5890 ;
    LAYER M5 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M5 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M5 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M5 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M5 ;
      RECT 7045 4200 7225 4850 ;
    LAYER M5 ;
      RECT 7045 4850 7225 5890 ;
    LAYER M5 ;
      RECT 7325 4850 7505 5890 ;
    LAYER M5 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M5 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M5 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M5 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M5 ;
      RECT 7605 4200 7785 4850 ;
    LAYER M5 ;
      RECT 7605 4850 7785 5890 ;
    LAYER M5 ;
      RECT 7885 4850 8065 5890 ;
    LAYER M5 ;
      RECT 8165 4200 8345 4850 ;
    LAYER M5 ;
      RECT 8165 4200 8345 4850 ;
    LAYER M5 ;
      RECT 8165 4200 8345 4850 ;
    LAYER M5 ;
      RECT 8165 4200 8345 4850 ;
    LAYER M5 ;
      RECT 8165 4200 8345 4850 ;
    LAYER M5 ;
      RECT 8165 4850 8345 5890 ;
    LAYER M5 ;
      RECT 8445 4850 8625 5890 ;
    LAYER M5 ;
      RECT 8725 4200 8905 4850 ;
    LAYER M5 ;
      RECT 8725 4200 8905 4850 ;
    LAYER M5 ;
      RECT 8725 4200 8905 4850 ;
    LAYER M5 ;
      RECT 8725 4200 8905 4850 ;
    LAYER M5 ;
      RECT 8725 4200 8905 4850 ;
    LAYER M5 ;
      RECT 8725 4850 8905 5890 ;
    LAYER M5 ;
      RECT 9005 4850 9185 5890 ;
    LAYER M5 ;
      RECT 9285 4200 9465 4850 ;
    LAYER M5 ;
      RECT 9285 4200 9465 4850 ;
    LAYER M5 ;
      RECT 9285 4200 9465 4850 ;
    LAYER M5 ;
      RECT 9285 4200 9465 4850 ;
    LAYER M5 ;
      RECT 9285 4200 9465 4850 ;
    LAYER M5 ;
      RECT 9285 4850 9465 5890 ;
    LAYER M5 ;
      RECT 9565 4850 9745 5890 ;
    LAYER M5 ;
      RECT 9845 4200 10025 4850 ;
    LAYER M5 ;
      RECT 9845 4200 10025 4850 ;
    LAYER M5 ;
      RECT 9845 4200 10025 4850 ;
    LAYER M5 ;
      RECT 9845 4200 10025 4850 ;
    LAYER M5 ;
      RECT 9845 4200 10025 4850 ;
    LAYER M5 ;
      RECT 9845 4850 10025 5890 ;
    LAYER M5 ;
      RECT 10125 4850 10305 5890 ;
    LAYER M5 ;
      RECT 10405 4200 10585 4850 ;
    LAYER M5 ;
      RECT 10405 4200 10585 4850 ;
    LAYER M5 ;
      RECT 10405 4200 10585 4850 ;
    LAYER M5 ;
      RECT 10405 4200 10585 4850 ;
    LAYER M5 ;
      RECT 10405 4200 10585 4850 ;
    LAYER M5 ;
      RECT 10405 4850 10585 5890 ;
    LAYER M5 ;
      RECT 10685 4850 10865 5890 ;
    LAYER M5 ;
      RECT 10965 4200 11145 4850 ;
    LAYER M5 ;
      RECT 10965 4200 11145 4850 ;
    LAYER M5 ;
      RECT 10965 4200 11145 4850 ;
    LAYER M5 ;
      RECT 10965 4200 11145 4850 ;
    LAYER M5 ;
      RECT 10965 4200 11145 4850 ;
    LAYER M5 ;
      RECT 10965 4850 11145 5890 ;
    LAYER M5 ;
      RECT 11245 4850 11425 5890 ;
    LAYER M5 ;
      RECT 11525 4200 11705 4850 ;
    LAYER M5 ;
      RECT 11525 4200 11705 4850 ;
    LAYER M5 ;
      RECT 11525 4200 11705 4850 ;
    LAYER M5 ;
      RECT 11525 4200 11705 4850 ;
    LAYER M5 ;
      RECT 11525 4200 11705 4850 ;
    LAYER M5 ;
      RECT 11525 4850 11705 5890 ;
    LAYER M5 ;
      RECT 11805 4850 11985 5890 ;
    LAYER M5 ;
      RECT 12085 4200 12265 4850 ;
    LAYER M5 ;
      RECT 12085 4200 12265 4850 ;
    LAYER M5 ;
      RECT 12085 4200 12265 4850 ;
    LAYER M5 ;
      RECT 12085 4200 12265 4850 ;
    LAYER M5 ;
      RECT 12085 4200 12265 4850 ;
    LAYER M5 ;
      RECT 12085 4850 12265 5890 ;
    LAYER M5 ;
      RECT 12365 4850 12545 5890 ;
    LAYER M5 ;
      RECT 12645 4200 12825 4850 ;
    LAYER M5 ;
      RECT 12645 4200 12825 4850 ;
    LAYER M5 ;
      RECT 12645 4200 12825 4850 ;
    LAYER M5 ;
      RECT 12645 4200 12825 4850 ;
    LAYER M5 ;
      RECT 12645 4200 12825 4850 ;
    LAYER M5 ;
      RECT 12645 4850 12825 5890 ;
    LAYER M5 ;
      RECT 12925 4850 13105 5890 ;
    LAYER M5 ;
      RECT 13205 4200 13385 4850 ;
    LAYER M5 ;
      RECT 13205 4200 13385 4850 ;
    LAYER M5 ;
      RECT 13205 4200 13385 4850 ;
    LAYER M5 ;
      RECT 13205 4200 13385 4850 ;
    LAYER M5 ;
      RECT 13205 4200 13385 4850 ;
    LAYER M5 ;
      RECT 13205 4850 13385 5890 ;
    LAYER M5 ;
      RECT 13485 4850 13665 5890 ;
    LAYER M5 ;
      RECT 13765 4200 13945 4850 ;
    LAYER M5 ;
      RECT 13765 4200 13945 4850 ;
    LAYER M5 ;
      RECT 13765 4200 13945 4850 ;
    LAYER M5 ;
      RECT 13765 4200 13945 4850 ;
    LAYER M5 ;
      RECT 13765 4200 13945 4850 ;
    LAYER M5 ;
      RECT 13765 4850 13945 5890 ;
    LAYER M5 ;
      RECT 1365 6350 14025 6710 ;
    LAYER M5 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M5 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M5 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M5 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M5 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M5 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M5 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M5 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M5 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M5 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6485 3160 6665 4200 ;
    LAYER M5 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M5 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M5 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M5 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M5 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M5 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M5 ;
      RECT 7045 3160 7225 4200 ;
    LAYER M5 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M5 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M5 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M5 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M5 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M5 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M5 ;
      RECT 7605 3160 7785 4200 ;
    LAYER M5 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M5 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M5 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M5 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M5 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M5 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M5 ;
      RECT 8165 3160 8345 4200 ;
    LAYER M5 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M5 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M5 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M5 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M5 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M5 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M5 ;
      RECT 8725 3160 8905 4200 ;
    LAYER M5 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M5 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M5 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M5 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M5 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M5 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M5 ;
      RECT 9285 3160 9465 4200 ;
    LAYER M5 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M5 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M5 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M5 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M5 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M5 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M5 ;
      RECT 9845 3160 10025 4200 ;
    LAYER M5 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M5 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M5 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M5 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M5 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M5 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M5 ;
      RECT 10405 3160 10585 4200 ;
    LAYER M5 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M5 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M5 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M5 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M5 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M5 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M5 ;
      RECT 10965 3160 11145 4200 ;
    LAYER M5 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M5 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M5 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M5 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M5 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M5 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M5 ;
      RECT 11525 3160 11705 4200 ;
    LAYER M5 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M5 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M5 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M5 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M5 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M5 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M5 ;
      RECT 12085 3160 12265 4200 ;
    LAYER M5 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M5 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M5 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M5 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M5 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M5 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M5 ;
      RECT 12645 3160 12825 4200 ;
    LAYER M5 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M5 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M5 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M5 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M5 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M5 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M5 ;
      RECT 13205 3160 13385 4200 ;
    LAYER M5 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M5 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M5 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M5 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M5 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M5 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M5 ;
      RECT 13765 3160 13945 4200 ;
    LAYER M5 ;
      RECT 1165 1470 14225 2000 ;
    LAYER Poly ;
      RECT 1365 4730 1425 5970 ;
    LAYER Poly ;
      RECT 1645 4730 1705 5970 ;
    LAYER Poly ;
      RECT 1925 4730 1985 5970 ;
    LAYER Poly ;
      RECT 2205 4730 2265 5970 ;
    LAYER Poly ;
      RECT 2485 4730 2545 5970 ;
    LAYER Poly ;
      RECT 2765 4730 2825 5970 ;
    LAYER Poly ;
      RECT 3045 4730 3105 5970 ;
    LAYER Poly ;
      RECT 3325 4730 3385 5970 ;
    LAYER Poly ;
      RECT 3605 4730 3665 5970 ;
    LAYER Poly ;
      RECT 3885 4730 3945 5970 ;
    LAYER Poly ;
      RECT 4165 4730 4225 5970 ;
    LAYER Poly ;
      RECT 4445 4730 4505 5970 ;
    LAYER Poly ;
      RECT 4725 4730 4785 5970 ;
    LAYER Poly ;
      RECT 5005 4730 5065 5970 ;
    LAYER Poly ;
      RECT 5285 4730 5345 5970 ;
    LAYER Poly ;
      RECT 5565 4730 5625 5970 ;
    LAYER Poly ;
      RECT 5845 4730 5905 5970 ;
    LAYER Poly ;
      RECT 6125 4730 6185 5970 ;
    LAYER Poly ;
      RECT 6405 4730 6465 5970 ;
    LAYER Poly ;
      RECT 6685 4730 6745 5970 ;
    LAYER Poly ;
      RECT 6965 4730 7025 5970 ;
    LAYER Poly ;
      RECT 7245 4730 7305 5970 ;
    LAYER Poly ;
      RECT 7525 4730 7585 5970 ;
    LAYER Poly ;
      RECT 7805 4730 7865 5970 ;
    LAYER Poly ;
      RECT 8085 4730 8145 5970 ;
    LAYER Poly ;
      RECT 8365 4730 8425 5970 ;
    LAYER Poly ;
      RECT 8645 4730 8705 5970 ;
    LAYER Poly ;
      RECT 8925 4730 8985 5970 ;
    LAYER Poly ;
      RECT 9205 4730 9265 5970 ;
    LAYER Poly ;
      RECT 9485 4730 9545 5970 ;
    LAYER Poly ;
      RECT 9765 4730 9825 5970 ;
    LAYER Poly ;
      RECT 10045 4730 10105 5970 ;
    LAYER Poly ;
      RECT 10325 4730 10385 5970 ;
    LAYER Poly ;
      RECT 10605 4730 10665 5970 ;
    LAYER Poly ;
      RECT 10885 4730 10945 5970 ;
    LAYER Poly ;
      RECT 11165 4730 11225 5970 ;
    LAYER Poly ;
      RECT 11445 4730 11505 5970 ;
    LAYER Poly ;
      RECT 11725 4730 11785 5970 ;
    LAYER Poly ;
      RECT 12005 4730 12065 5970 ;
    LAYER Poly ;
      RECT 12285 4730 12345 5970 ;
    LAYER Poly ;
      RECT 12565 4730 12625 5970 ;
    LAYER Poly ;
      RECT 12845 4730 12905 5970 ;
    LAYER Poly ;
      RECT 13125 4730 13185 5970 ;
    LAYER Poly ;
      RECT 13405 4730 13465 5970 ;
    LAYER Poly ;
      RECT 13685 4730 13745 5970 ;
    LAYER Poly ;
      RECT 13965 4730 14025 5970 ;
    LAYER Poly ;
      RECT 1365 5970 14025 6180 ;
    LAYER Poly ;
      RECT 1365 3080 1425 4280 ;
    LAYER Poly ;
      RECT 1645 3080 1705 4280 ;
    LAYER Poly ;
      RECT 1925 3080 1985 4280 ;
    LAYER Poly ;
      RECT 2205 3080 2265 4280 ;
    LAYER Poly ;
      RECT 2485 3080 2545 4280 ;
    LAYER Poly ;
      RECT 2765 3080 2825 4280 ;
    LAYER Poly ;
      RECT 3045 3080 3105 4280 ;
    LAYER Poly ;
      RECT 3325 3080 3385 4280 ;
    LAYER Poly ;
      RECT 3605 3080 3665 4280 ;
    LAYER Poly ;
      RECT 3885 3080 3945 4280 ;
    LAYER Poly ;
      RECT 4165 3080 4225 4280 ;
    LAYER Poly ;
      RECT 4445 3080 4505 4280 ;
    LAYER Poly ;
      RECT 4725 3080 4785 4280 ;
    LAYER Poly ;
      RECT 5005 3080 5065 4280 ;
    LAYER Poly ;
      RECT 5285 3080 5345 4280 ;
    LAYER Poly ;
      RECT 5565 3080 5625 4280 ;
    LAYER Poly ;
      RECT 5845 3080 5905 4280 ;
    LAYER Poly ;
      RECT 6125 3080 6185 4280 ;
    LAYER Poly ;
      RECT 6405 3080 6465 4280 ;
    LAYER Poly ;
      RECT 6685 3080 6745 4280 ;
    LAYER Poly ;
      RECT 6965 3080 7025 4280 ;
    LAYER Poly ;
      RECT 7245 3080 7305 4280 ;
    LAYER Poly ;
      RECT 7525 3080 7585 4280 ;
    LAYER Poly ;
      RECT 7805 3080 7865 4280 ;
    LAYER Poly ;
      RECT 8085 3080 8145 4280 ;
    LAYER Poly ;
      RECT 8365 3080 8425 4280 ;
    LAYER Poly ;
      RECT 8645 3080 8705 4280 ;
    LAYER Poly ;
      RECT 8925 3080 8985 4280 ;
    LAYER Poly ;
      RECT 9205 3080 9265 4280 ;
    LAYER Poly ;
      RECT 9485 3080 9545 4280 ;
    LAYER Poly ;
      RECT 9765 3080 9825 4280 ;
    LAYER Poly ;
      RECT 10045 3080 10105 4280 ;
    LAYER Poly ;
      RECT 10325 3080 10385 4280 ;
    LAYER Poly ;
      RECT 10605 3080 10665 4280 ;
    LAYER Poly ;
      RECT 10885 3080 10945 4280 ;
    LAYER Poly ;
      RECT 11165 3080 11225 4280 ;
    LAYER Poly ;
      RECT 11445 3080 11505 4280 ;
    LAYER Poly ;
      RECT 11725 3080 11785 4280 ;
    LAYER Poly ;
      RECT 12005 3080 12065 4280 ;
    LAYER Poly ;
      RECT 12285 3080 12345 4280 ;
    LAYER Poly ;
      RECT 12565 3080 12625 4280 ;
    LAYER Poly ;
      RECT 12845 3080 12905 4280 ;
    LAYER Poly ;
      RECT 13125 3080 13185 4280 ;
    LAYER Poly ;
      RECT 13405 3080 13465 4280 ;
    LAYER Poly ;
      RECT 13685 3080 13745 4280 ;
    LAYER Poly ;
      RECT 13965 3080 14025 4280 ;
    LAYER Poly ;
      RECT 1365 4280 14025 4490 ;
    LAYER Poly ;
      RECT 1365 2870 14025 3080 ;
    LAYER M7 ;
      RECT 0 4850 14225 5890 ;
    LAYER M7 ;
      RECT 1365 6710 14025 7410 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M7 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M7 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 14045 3160 14225 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 14045 2000 14225 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M7 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M7 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M7 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M7 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M7 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M7 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M7 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M7 ;
      RECT 6765 3160 6945 4200 ;
    LAYER M7 ;
      RECT 6765 2000 6945 3160 ;
    LAYER M7 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M7 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M7 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M7 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M7 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M7 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M7 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M7 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M7 ;
      RECT 7325 3160 7505 4200 ;
    LAYER M7 ;
      RECT 7325 2000 7505 3160 ;
    LAYER M7 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M7 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M7 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M7 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M7 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M7 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M7 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M7 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M7 ;
      RECT 7885 3160 8065 4200 ;
    LAYER M7 ;
      RECT 7885 2000 8065 3160 ;
    LAYER M7 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M7 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M7 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M7 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M7 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M7 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M7 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M7 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M7 ;
      RECT 8445 3160 8625 4200 ;
    LAYER M7 ;
      RECT 8445 2000 8625 3160 ;
    LAYER M7 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M7 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M7 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M7 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M7 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M7 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M7 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M7 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M7 ;
      RECT 9005 3160 9185 4200 ;
    LAYER M7 ;
      RECT 9005 2000 9185 3160 ;
    LAYER M7 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M7 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M7 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M7 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M7 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M7 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M7 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M7 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M7 ;
      RECT 9565 3160 9745 4200 ;
    LAYER M7 ;
      RECT 9565 2000 9745 3160 ;
    LAYER M7 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M7 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M7 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M7 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M7 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M7 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M7 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M7 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M7 ;
      RECT 10125 3160 10305 4200 ;
    LAYER M7 ;
      RECT 10125 2000 10305 3160 ;
    LAYER M7 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M7 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M7 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M7 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M7 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M7 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M7 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M7 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M7 ;
      RECT 10685 3160 10865 4200 ;
    LAYER M7 ;
      RECT 10685 2000 10865 3160 ;
    LAYER M7 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M7 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M7 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M7 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M7 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M7 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M7 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M7 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M7 ;
      RECT 11245 3160 11425 4200 ;
    LAYER M7 ;
      RECT 11245 2000 11425 3160 ;
    LAYER M7 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M7 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M7 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M7 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M7 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M7 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M7 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M7 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M7 ;
      RECT 11805 3160 11985 4200 ;
    LAYER M7 ;
      RECT 11805 2000 11985 3160 ;
    LAYER M7 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M7 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M7 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M7 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M7 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M7 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M7 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M7 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M7 ;
      RECT 12365 3160 12545 4200 ;
    LAYER M7 ;
      RECT 12365 2000 12545 3160 ;
    LAYER M7 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M7 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M7 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M7 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M7 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M7 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M7 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M7 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M7 ;
      RECT 12925 3160 13105 4200 ;
    LAYER M7 ;
      RECT 12925 2000 13105 3160 ;
    LAYER M7 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M7 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M7 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M7 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M7 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M7 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M7 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M7 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M7 ;
      RECT 13485 3160 13665 4200 ;
    LAYER M7 ;
      RECT 13485 2000 13665 3160 ;
    LAYER M7 ;
      RECT 1165 1470 14225 2000 ;
    LAYER M8 ;
      RECT 1365 6710 14025 7750 ;
    LAYER M8 ;
      RECT 1165 760 14225 2000 ;
    LAYER M9 ;
      RECT 1365 6530 14025 8530 ;
    LAYER M9 ;
      RECT 1165 0 14225 2000 ;
  END
END Stage_2
MACRO bias1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias1 0 0 ;
  SIZE 2810 BY 2540 ;
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 220 2140 2590 2540 ;
    END
  END G
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M2 ;
        RECT 220 0 2590 450 ;
    END
  END D
  PIN BS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 2310 1150 2590 1390 ;
    END
  END BS
  OBS
    LAYER M2 ;
      RECT 220 0 2590 500 ;
    LAYER M2 ;
      RECT 1595 230 1775 1150 ;
    LAYER M2 ;
      RECT 1035 230 1215 1150 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M2 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 2040 2590 2540 ;
    LAYER M3 ;
      RECT 955 1665 1855 2175 ;
    LAYER M3 ;
      RECT 955 1485 1855 1665 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M4 ;
      RECT 490 1150 2485 1390 ;
    LAYER M4 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M4 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M4 ;
      RECT 755 1150 935 1390 ;
    LAYER M4 ;
      RECT 220 1150 500 1390 ;
    LAYER M4 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 1080 1150 1170 1390 ;
    LAYER M1 ;
      RECT 1360 1150 1450 1390 ;
    LAYER M1 ;
      RECT 1640 1150 1730 1390 ;
    LAYER M1 ;
      RECT 1920 1150 2010 1390 ;
    LAYER M1 ;
      RECT 800 1150 890 1390 ;
    LAYER M1 ;
      RECT 955 1485 1855 1665 ;
    LAYER M1 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M1 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M1 ;
      RECT 755 1150 935 1390 ;
    LAYER M1 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M1 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M1 ;
      RECT 220 710 500 1170 ;
    LAYER M1 ;
      RECT 2310 710 2590 1170 ;
    LAYER M1 ;
      RECT 220 1370 500 1830 ;
    LAYER M1 ;
      RECT 2310 1370 2590 1830 ;
    LAYER M1 ;
      RECT 220 500 2590 710 ;
    LAYER M1 ;
      RECT 220 1830 2590 2040 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 955 1530 1855 1620 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER Poly ;
      RECT 955 1470 1855 1680 ;
    LAYER Poly ;
      RECT 955 1030 1015 1170 ;
    LAYER Poly ;
      RECT 955 1370 1015 1470 ;
    LAYER Poly ;
      RECT 1235 1030 1295 1170 ;
    LAYER Poly ;
      RECT 1235 1370 1295 1470 ;
    LAYER Poly ;
      RECT 1515 1030 1575 1170 ;
    LAYER Poly ;
      RECT 1515 1370 1575 1470 ;
    LAYER Poly ;
      RECT 1795 1030 1855 1170 ;
    LAYER Poly ;
      RECT 1795 1370 1855 1470 ;
    LAYER Poly ;
      RECT 1795 1170 1855 1370 ;
    LAYER Poly ;
      RECT 1515 1170 1575 1370 ;
    LAYER Poly ;
      RECT 1235 1170 1295 1370 ;
    LAYER Poly ;
      RECT 955 1170 1015 1370 ;
  END
END bias1
MACRO bias2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias2 0 0 ;
  SIZE 2810 BY 2540 ;
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 220 2140 2590 2540 ;
    END
  END G
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M2 ;
        RECT 220 0 2590 450 ;
    END
  END D
  PIN BS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 2310 1150 2590 1390 ;
    END
  END BS
  OBS
    LAYER M2 ;
      RECT 220 0 2590 500 ;
    LAYER M2 ;
      RECT 1595 230 1775 1150 ;
    LAYER M2 ;
      RECT 1035 230 1215 1150 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M2 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 2040 2590 2540 ;
    LAYER M3 ;
      RECT 955 1665 1855 2175 ;
    LAYER M3 ;
      RECT 955 1485 1855 1665 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M4 ;
      RECT 490 1150 2485 1390 ;
    LAYER M4 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M4 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M4 ;
      RECT 755 1150 935 1390 ;
    LAYER M4 ;
      RECT 220 1150 500 1390 ;
    LAYER M4 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 1080 1150 1170 1390 ;
    LAYER M1 ;
      RECT 1360 1150 1450 1390 ;
    LAYER M1 ;
      RECT 1640 1150 1730 1390 ;
    LAYER M1 ;
      RECT 1920 1150 2010 1390 ;
    LAYER M1 ;
      RECT 800 1150 890 1390 ;
    LAYER M1 ;
      RECT 955 1485 1855 1665 ;
    LAYER M1 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M1 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M1 ;
      RECT 755 1150 935 1390 ;
    LAYER M1 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M1 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M1 ;
      RECT 220 710 500 1170 ;
    LAYER M1 ;
      RECT 2310 710 2590 1170 ;
    LAYER M1 ;
      RECT 220 1370 500 1830 ;
    LAYER M1 ;
      RECT 2310 1370 2590 1830 ;
    LAYER M1 ;
      RECT 220 500 2590 710 ;
    LAYER M1 ;
      RECT 220 1830 2590 2040 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 955 1530 1855 1620 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER Poly ;
      RECT 955 1470 1855 1680 ;
    LAYER Poly ;
      RECT 955 1030 1015 1170 ;
    LAYER Poly ;
      RECT 955 1370 1015 1470 ;
    LAYER Poly ;
      RECT 1235 1030 1295 1170 ;
    LAYER Poly ;
      RECT 1235 1370 1295 1470 ;
    LAYER Poly ;
      RECT 1515 1030 1575 1170 ;
    LAYER Poly ;
      RECT 1515 1370 1575 1470 ;
    LAYER Poly ;
      RECT 1795 1030 1855 1170 ;
    LAYER Poly ;
      RECT 1795 1370 1855 1470 ;
    LAYER Poly ;
      RECT 1795 1170 1855 1370 ;
    LAYER Poly ;
      RECT 1515 1170 1575 1370 ;
    LAYER Poly ;
      RECT 1235 1170 1295 1370 ;
    LAYER Poly ;
      RECT 955 1170 1015 1370 ;
  END
END bias2
MACRO gnd0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gnd0 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END gnd0
MACRO gnd1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gnd1 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END gnd1
MACRO gnd2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gnd2 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END gnd2
MACRO gnd3
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gnd3 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END gnd3
MACRO output
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN output 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END output
MACRO vdd0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN vdd0 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END vdd0
MACRO vdd1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN vdd1 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END vdd1
MACRO vdd2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN vdd2 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END vdd2
MACRO vdd3
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN vdd3 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END vdd3

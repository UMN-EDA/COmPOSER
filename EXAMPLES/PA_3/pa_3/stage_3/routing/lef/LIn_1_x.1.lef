MACRO LIn_1_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_1_x.1 0 0 ;
  SIZE 127712 BY 119214 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 123712 61547 127712 65547 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 123712 53667 127712 57667 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 108712 54607 118712 64607 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 75962 61547 95712 65547 ;
    LAYER M8 ;
      RECT 0 0 119214 119214 ;
    LAYER M9 ;
      RECT 91712 61547 127712 65547 ;
    LAYER M9 ;
      RECT 23502 25467 95712 93747 ;
    LAYER M9 ;
      RECT 91712 53667 127712 57667 ;
    LAYER M9 ;
      RECT 0 0 119214 119214 ;
    LAYER M1 ;
      RECT 0 0 119214 119214 ;
    LAYER M2 ;
      RECT 0 0 119214 119214 ;
    LAYER M3 ;
      RECT 0 0 119214 119214 ;
    LAYER M4 ;
      RECT 0 0 119214 119214 ;
    LAYER M5 ;
      RECT 0 0 119214 119214 ;
    LAYER M6 ;
      RECT 0 0 119214 119214 ;
    LAYER M7 ;
      RECT 0 0 119214 119214 ;
  END
END LIn_1_x.1

MACRO CSeries_D_2_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CSeries_D_2_1 0 0 ;
  SIZE 8150 BY 9590 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 9490 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 6870 4065 8150 5525 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 8030 6470 9490 ;
    LAYER M8 ;
      RECT 0 100 6470 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 8030 ;
    LAYER M8 ;
      RECT 1680 4065 8150 5525 ;
    LAYER M8 ;
      RECT 1820 2540 3280 7050 ;
    LAYER M8 ;
      RECT 4870 2540 6330 7050 ;
  END
END CSeries_D_2_1

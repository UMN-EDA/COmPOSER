MACRO LD_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_2 0 0 ;
  SIZE 90000 BY 44000 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 4000 24000 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 86000 20000 90000 24000 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 90000 24000 ;
    LAYER M1 ;
      RECT 4000 0 86000 44000 ;
  END
END LD_2

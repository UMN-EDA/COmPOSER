MACRO LIn_1_x.75
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_1_x.75 0 0 ;
  SIZE 129482 BY 131232 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 124982 67925 129482 72425 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 58807 0 63307 4500 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 111732 65175 121732 75175 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 85732 67925 104232 72425 ;
    LAYER M8 ;
      RECT 0 9118 122114 131232 ;
    LAYER M9 ;
      RECT 99732 67925 129482 72425 ;
    LAYER M9 ;
      RECT 24882 32250 97232 108100 ;
    LAYER M9 ;
      RECT 58807 0 63307 36750 ;
    LAYER M9 ;
      RECT 0 9118 122114 131232 ;
    LAYER M1 ;
      RECT 0 9118 122114 131232 ;
    LAYER M2 ;
      RECT 0 9118 122114 131232 ;
    LAYER M3 ;
      RECT 0 9118 122114 131232 ;
    LAYER M4 ;
      RECT 0 9118 122114 131232 ;
    LAYER M5 ;
      RECT 0 9118 122114 131232 ;
    LAYER M6 ;
      RECT 0 9118 122114 131232 ;
    LAYER M7 ;
      RECT 0 9118 122114 131232 ;
  END
END LIn_1_x.75

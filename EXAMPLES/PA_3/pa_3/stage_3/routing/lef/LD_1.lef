MACRO LD_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_1 0 0 ;
  SIZE 125000 BY 47500 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 7500 27500 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 117500 20000 125000 27500 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 125000 27500 ;
    LAYER M1 ;
      RECT 7500 0 117500 47500 ;
  END
END LD_1

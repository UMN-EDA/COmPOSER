MACRO LIn_2_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_2_x.1 0 0 ;
  SIZE 118528 BY 114236 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 115528 58928 118528 61928 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 115528 52308 118528 55308 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 103528 52118 113528 62118 ;
    END
  END GND
  OBS
    LAYER M9 ;
      RECT 24208 24208 90028 90028 ;
    LAYER M9 ;
      RECT 87028 58928 118528 61928 ;
    LAYER M9 ;
      RECT 87028 52308 118528 55308 ;
    LAYER M9 ;
      RECT 0 0 114236 114236 ;
    LAYER M1 ;
      RECT 0 0 114236 114236 ;
    LAYER M2 ;
      RECT 0 0 114236 114236 ;
    LAYER M3 ;
      RECT 0 0 114236 114236 ;
    LAYER M4 ;
      RECT 0 0 114236 114236 ;
    LAYER M5 ;
      RECT 0 0 114236 114236 ;
    LAYER M6 ;
      RECT 0 0 114236 114236 ;
    LAYER M7 ;
      RECT 0 0 114236 114236 ;
    LAYER M8 ;
      RECT 0 0 114236 114236 ;
  END
END LIn_2_x.1

MACRO Cnew1_3
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN Cnew1_3 0 0 ;
  SIZE 14610 BY 21780 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6075 21350 8535 21780 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6075 0 8535 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 9710 1660 12070 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 12950 7845 14610 13935 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 12910 12110 21780 ;
    LAYER M8 ;
      RECT 2500 0 12110 8870 ;
    LAYER M8 ;
      RECT 12110 20120 14610 21780 ;
    LAYER M8 ;
      RECT 12110 0 14610 1660 ;
    LAYER M8 ;
      RECT 12950 0 14610 21780 ;
    LAYER M8 ;
      RECT 0 9710 12110 12070 ;
    LAYER M8 ;
      RECT 5000 12070 6740 19280 ;
    LAYER M8 ;
      RECT 5000 12070 6740 19280 ;
    LAYER M8 ;
      RECT 5000 2500 6740 9710 ;
    LAYER M8 ;
      RECT 7870 12070 9610 19280 ;
    LAYER M8 ;
      RECT 7870 12070 9610 19280 ;
    LAYER M8 ;
      RECT 7870 2500 9610 9710 ;
    LAYER M5 ;
      RECT 6705 0 7905 21780 ;
    LAYER M5 ;
      RECT 2500 10290 12110 11490 ;
    LAYER M5 ;
      RECT 8505 12690 9705 21780 ;
    LAYER M5 ;
      RECT 8505 12090 12110 13290 ;
    LAYER M5 ;
      RECT 10305 14490 11505 21780 ;
    LAYER M5 ;
      RECT 10305 13890 12110 15090 ;
    LAYER M5 ;
      RECT 12105 16290 12110 21780 ;
    LAYER M5 ;
      RECT 12105 15690 12110 16890 ;
    LAYER M5 ;
      RECT 4905 12690 6105 21780 ;
    LAYER M5 ;
      RECT 2500 12090 6105 13290 ;
    LAYER M5 ;
      RECT 3105 14490 4305 21780 ;
    LAYER M5 ;
      RECT 2500 13890 4305 15090 ;
    LAYER M5 ;
      RECT 2500 16290 2505 21780 ;
    LAYER M5 ;
      RECT 2500 15690 2505 16890 ;
    LAYER M5 ;
      RECT 4905 0 6105 9090 ;
    LAYER M5 ;
      RECT 2500 8490 6105 9690 ;
    LAYER M5 ;
      RECT 3105 0 4305 7290 ;
    LAYER M5 ;
      RECT 2500 6690 4305 7890 ;
    LAYER M5 ;
      RECT 2500 0 2505 5490 ;
    LAYER M5 ;
      RECT 2500 4890 2505 6090 ;
    LAYER M5 ;
      RECT 8505 0 9705 9090 ;
    LAYER M5 ;
      RECT 8505 8490 12110 9690 ;
    LAYER M5 ;
      RECT 10305 0 11505 7290 ;
    LAYER M5 ;
      RECT 10305 6690 12110 7890 ;
    LAYER M5 ;
      RECT 12105 0 12110 5490 ;
    LAYER M5 ;
      RECT 12105 4890 12110 6090 ;
    LAYER M5 ;
      RECT 2500 21350 12110 21780 ;
    LAYER M5 ;
      RECT 2500 0 12110 430 ;
    LAYER M6 ;
      RECT 7605 11790 8805 21780 ;
    LAYER M6 ;
      RECT 7605 11190 12110 12390 ;
    LAYER M6 ;
      RECT 9405 13590 10605 21780 ;
    LAYER M6 ;
      RECT 9405 12990 12110 14190 ;
    LAYER M6 ;
      RECT 11205 15390 12110 21780 ;
    LAYER M6 ;
      RECT 11205 14790 12110 15990 ;
    LAYER M6 ;
      RECT 5805 11790 7005 21780 ;
    LAYER M6 ;
      RECT 2500 11190 7005 12390 ;
    LAYER M6 ;
      RECT 4005 13590 5205 21780 ;
    LAYER M6 ;
      RECT 2500 12990 5205 14190 ;
    LAYER M6 ;
      RECT 2500 15390 3405 21780 ;
    LAYER M6 ;
      RECT 2500 14790 3405 15990 ;
    LAYER M6 ;
      RECT 5805 0 7005 9990 ;
    LAYER M6 ;
      RECT 2500 9390 7005 10590 ;
    LAYER M6 ;
      RECT 4005 0 5205 8190 ;
    LAYER M6 ;
      RECT 2500 7590 5205 8790 ;
    LAYER M6 ;
      RECT 2500 0 3405 6390 ;
    LAYER M6 ;
      RECT 2500 5790 3405 6990 ;
    LAYER M6 ;
      RECT 7605 0 8805 9990 ;
    LAYER M6 ;
      RECT 7605 9390 12110 10590 ;
    LAYER M6 ;
      RECT 9405 0 10605 8190 ;
    LAYER M6 ;
      RECT 9405 7590 12110 8790 ;
    LAYER M6 ;
      RECT 11205 0 12110 6390 ;
    LAYER M6 ;
      RECT 11205 5790 12110 6990 ;
    LAYER M6 ;
      RECT 2500 21350 12110 21780 ;
    LAYER M6 ;
      RECT 2500 0 12110 430 ;
  END
END Cnew1_3

MACRO CShunt_D_1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CShunt_D_1_1 0 0 ;
  SIZE 8170 BY 9610 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 9510 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 6890 4075 8170 5535 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 8050 6490 9510 ;
    LAYER M8 ;
      RECT 0 100 6490 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 8050 ;
    LAYER M8 ;
      RECT 1680 4075 8170 5535 ;
    LAYER M8 ;
      RECT 1820 2540 3280 7070 ;
    LAYER M8 ;
      RECT 4890 2540 6350 7070 ;
  END
END CShunt_D_1_1

MACRO CSeries_D_1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CSeries_D_1_1 0 0 ;
  SIZE 7040 BY 8480 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 8380 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 5760 3510 7040 4970 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 6920 5360 8380 ;
    LAYER M8 ;
      RECT 0 100 5360 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 6920 ;
    LAYER M8 ;
      RECT 1680 3510 7040 4970 ;
    LAYER M8 ;
      RECT 1820 2540 3280 5940 ;
    LAYER M8 ;
      RECT 3760 2540 5220 5940 ;
  END
END CSeries_D_1_1

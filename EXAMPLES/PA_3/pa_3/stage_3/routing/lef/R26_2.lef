MACRO R26_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R26_2 0 0 ;
  SIZE 1880 BY 6440 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 6220 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1560 220 1650 6220 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 1680 6220 ;
    LAYER RPO ;
      RECT 540 0 1340 6440 ;
    LAYER M1 ;
      RECT 230 235 320 6205 ;
    LAYER M1 ;
      RECT 1560 235 1650 6205 ;
    LAYER RH ;
      RECT 0 20 1880 6420 ;
  END
END R26_2

MACRO R1_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R1_0 0 0 ;
  SIZE 6050 BY 5140 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4920 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 5730 220 5820 4920 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 5850 4920 ;
    LAYER RPO ;
      RECT 540 0 5510 5140 ;
    LAYER M1 ;
      RECT 230 235 320 4905 ;
    LAYER M1 ;
      RECT 5730 235 5820 4905 ;
    LAYER RH ;
      RECT 0 20 6050 5120 ;
  END
END R1_0

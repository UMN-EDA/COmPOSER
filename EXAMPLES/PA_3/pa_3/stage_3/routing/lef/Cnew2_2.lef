MACRO Cnew2_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN Cnew2_2 0 0 ;
  SIZE 16470 BY 19420 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6695 18990 9775 19420 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6695 0 9775 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 8530 1660 10890 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 14810 5735 16470 13685 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 11730 13970 19420 ;
    LAYER M8 ;
      RECT 2500 0 13970 7690 ;
    LAYER M8 ;
      RECT 13970 17760 16470 19420 ;
    LAYER M8 ;
      RECT 13970 0 16470 1660 ;
    LAYER M8 ;
      RECT 14810 0 16470 19420 ;
    LAYER M8 ;
      RECT 0 8530 13970 10890 ;
    LAYER M8 ;
      RECT 5000 10890 6740 16920 ;
    LAYER M8 ;
      RECT 5000 10890 6740 16920 ;
    LAYER M8 ;
      RECT 5000 2500 6740 8530 ;
    LAYER M8 ;
      RECT 9730 10890 11470 16920 ;
    LAYER M8 ;
      RECT 9730 10890 11470 16920 ;
    LAYER M8 ;
      RECT 9730 2500 11470 8530 ;
    LAYER M5 ;
      RECT 7635 0 8835 19420 ;
    LAYER M5 ;
      RECT 2500 9110 13970 10310 ;
    LAYER M5 ;
      RECT 9435 11510 10635 19420 ;
    LAYER M5 ;
      RECT 9435 10910 13970 12110 ;
    LAYER M5 ;
      RECT 11235 13310 12435 19420 ;
    LAYER M5 ;
      RECT 11235 12710 13970 13910 ;
    LAYER M5 ;
      RECT 13035 15110 13970 19420 ;
    LAYER M5 ;
      RECT 13035 14510 13970 15710 ;
    LAYER M5 ;
      RECT 5835 11510 7035 19420 ;
    LAYER M5 ;
      RECT 2500 10910 7035 12110 ;
    LAYER M5 ;
      RECT 4035 13310 5235 19420 ;
    LAYER M5 ;
      RECT 2500 12710 5235 13910 ;
    LAYER M5 ;
      RECT 2500 15110 3435 19420 ;
    LAYER M5 ;
      RECT 2500 14510 3435 15710 ;
    LAYER M5 ;
      RECT 5835 0 7035 7910 ;
    LAYER M5 ;
      RECT 2500 7310 7035 8510 ;
    LAYER M5 ;
      RECT 4035 0 5235 6110 ;
    LAYER M5 ;
      RECT 2500 5510 5235 6710 ;
    LAYER M5 ;
      RECT 2500 0 3435 4310 ;
    LAYER M5 ;
      RECT 2500 3710 3435 4910 ;
    LAYER M5 ;
      RECT 9435 0 10635 7910 ;
    LAYER M5 ;
      RECT 9435 7310 13970 8510 ;
    LAYER M5 ;
      RECT 11235 0 12435 6110 ;
    LAYER M5 ;
      RECT 11235 5510 13970 6710 ;
    LAYER M5 ;
      RECT 13035 0 13970 4310 ;
    LAYER M5 ;
      RECT 13035 3710 13970 4910 ;
    LAYER M5 ;
      RECT 2500 18990 13970 19420 ;
    LAYER M5 ;
      RECT 2500 0 13970 430 ;
    LAYER M6 ;
      RECT 8535 10610 9735 19420 ;
    LAYER M6 ;
      RECT 8535 10010 13970 11210 ;
    LAYER M6 ;
      RECT 10335 12410 11535 19420 ;
    LAYER M6 ;
      RECT 10335 11810 13970 13010 ;
    LAYER M6 ;
      RECT 12135 14210 13335 19420 ;
    LAYER M6 ;
      RECT 12135 13610 13970 14810 ;
    LAYER M6 ;
      RECT 6735 10610 7935 19420 ;
    LAYER M6 ;
      RECT 2500 10010 7935 11210 ;
    LAYER M6 ;
      RECT 4935 12410 6135 19420 ;
    LAYER M6 ;
      RECT 2500 11810 6135 13010 ;
    LAYER M6 ;
      RECT 3135 14210 4335 19420 ;
    LAYER M6 ;
      RECT 2500 13610 4335 14810 ;
    LAYER M6 ;
      RECT 6735 0 7935 8810 ;
    LAYER M6 ;
      RECT 2500 8210 7935 9410 ;
    LAYER M6 ;
      RECT 4935 0 6135 7010 ;
    LAYER M6 ;
      RECT 2500 6410 6135 7610 ;
    LAYER M6 ;
      RECT 3135 0 4335 5210 ;
    LAYER M6 ;
      RECT 2500 4610 4335 5810 ;
    LAYER M6 ;
      RECT 8535 0 9735 8810 ;
    LAYER M6 ;
      RECT 8535 8210 13970 9410 ;
    LAYER M6 ;
      RECT 10335 0 11535 7010 ;
    LAYER M6 ;
      RECT 10335 6410 13970 7610 ;
    LAYER M6 ;
      RECT 12135 0 13335 5210 ;
    LAYER M6 ;
      RECT 12135 4610 13970 5810 ;
    LAYER M6 ;
      RECT 2500 18990 13970 19420 ;
    LAYER M6 ;
      RECT 2500 0 13970 430 ;
  END
END Cnew2_2

MACRO gate_ind_x.25
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gate_ind_x.25 0 0 ;
  SIZE 126482 BY 128482 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 121982 57487 126482 61987 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 57487 123982 61987 128482 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 108982 54737 118982 64737 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 73732 57487 102232 61987 ;
    LAYER M8 ;
      RECT 0 0 119474 119474 ;
    LAYER M9 ;
      RECT 97732 57487 126482 61987 ;
    LAYER M9 ;
      RECT 25242 23242 94232 96232 ;
    LAYER M9 ;
      RECT 57487 91732 61987 128482 ;
    LAYER M9 ;
      RECT 0 0 119474 119474 ;
    LAYER M1 ;
      RECT 0 0 119474 119474 ;
    LAYER M2 ;
      RECT 0 0 119474 119474 ;
    LAYER M3 ;
      RECT 0 0 119474 119474 ;
    LAYER M4 ;
      RECT 0 0 119474 119474 ;
    LAYER M5 ;
      RECT 0 0 119474 119474 ;
    LAYER M6 ;
      RECT 0 0 119474 119474 ;
    LAYER M7 ;
      RECT 0 0 119474 119474 ;
  END
END gate_ind_x.25

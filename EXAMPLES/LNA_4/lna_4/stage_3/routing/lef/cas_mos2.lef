MACRO cas_mos2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN cas_mos2 0 0 ;
  SIZE 5225 BY 8530 ;
  PIN SS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M7 ;
        RECT 0 4850 300 5890 ;
    END
  END SS
  PIN GG
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1365 7530 4225 8530 ;
    END
  END GG
  PIN DD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1165 0 4145 1000 ;
    END
  END DD
  PIN G2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 4725 2880 5225 4480 ;
    END
  END G2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 700 4368 910 4578 ;
    END
  END GND
  OBS
    LAYER M6 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 1365 6530 4225 6890 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 1165 1470 4145 2000 ;
    LAYER M1 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M1 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M1 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M1 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M1 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M1 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M1 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M1 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M1 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M1 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M1 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M1 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M1 ;
      RECT 1365 5990 4225 6170 ;
    LAYER M1 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M1 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M1 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M1 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M1 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M1 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M1 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M1 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M1 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M1 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M1 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M1 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M1 ;
      RECT 1365 4300 4225 4480 ;
    LAYER M1 ;
      RECT 1365 2880 4225 3060 ;
    LAYER M1 ;
      RECT 700 2510 4890 6540 ;
    LAYER M2 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M2 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M2 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M2 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M2 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M2 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M2 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M2 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M2 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M2 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M2 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M2 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M2 ;
      RECT 1365 5990 4225 6170 ;
    LAYER M2 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M2 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M2 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M2 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M2 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M2 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M2 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M2 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M2 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M2 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M2 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M2 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M2 ;
      RECT 1365 4300 4225 4480 ;
    LAYER M2 ;
      RECT 1365 2880 4225 3060 ;
    LAYER M3 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M3 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M3 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M3 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M3 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M3 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M3 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M3 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M3 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M3 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M3 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M3 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M3 ;
      RECT 1365 5990 4225 6170 ;
    LAYER M3 ;
      RECT 1365 6170 4225 6350 ;
    LAYER M3 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M3 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M3 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M3 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M3 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M3 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M3 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M3 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M3 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M3 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M3 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M3 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M3 ;
      RECT 1365 4300 4225 4480 ;
    LAYER M3 ;
      RECT 4225 4300 4725 4480 ;
    LAYER M3 ;
      RECT 1365 2880 4225 3060 ;
    LAYER M3 ;
      RECT 4225 2880 4725 3060 ;
    LAYER M3 ;
      RECT 4725 2880 5225 4480 ;
    LAYER M4 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M4 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M4 ;
      RECT 4245 4200 4425 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M4 ;
      RECT 1365 6170 4225 6530 ;
    LAYER M4 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M4 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M4 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M4 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M4 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M4 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M4 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M4 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M4 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M4 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M4 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M4 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M5 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M5 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M5 ;
      RECT 4245 4200 4425 5890 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M5 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M5 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M5 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M5 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M5 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M5 ;
      RECT 1365 6350 4225 6710 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 1165 1470 4145 2000 ;
    LAYER Poly ;
      RECT 1365 4730 1425 5970 ;
    LAYER Poly ;
      RECT 1645 4730 1705 5970 ;
    LAYER Poly ;
      RECT 1925 4730 1985 5970 ;
    LAYER Poly ;
      RECT 2205 4730 2265 5970 ;
    LAYER Poly ;
      RECT 2485 4730 2545 5970 ;
    LAYER Poly ;
      RECT 2765 4730 2825 5970 ;
    LAYER Poly ;
      RECT 3045 4730 3105 5970 ;
    LAYER Poly ;
      RECT 3325 4730 3385 5970 ;
    LAYER Poly ;
      RECT 3605 4730 3665 5970 ;
    LAYER Poly ;
      RECT 3885 4730 3945 5970 ;
    LAYER Poly ;
      RECT 4165 4730 4225 5970 ;
    LAYER Poly ;
      RECT 1365 5970 4225 6180 ;
    LAYER Poly ;
      RECT 1365 3080 1425 4280 ;
    LAYER Poly ;
      RECT 1645 3080 1705 4280 ;
    LAYER Poly ;
      RECT 1925 3080 1985 4280 ;
    LAYER Poly ;
      RECT 2205 3080 2265 4280 ;
    LAYER Poly ;
      RECT 2485 3080 2545 4280 ;
    LAYER Poly ;
      RECT 2765 3080 2825 4280 ;
    LAYER Poly ;
      RECT 3045 3080 3105 4280 ;
    LAYER Poly ;
      RECT 3325 3080 3385 4280 ;
    LAYER Poly ;
      RECT 3605 3080 3665 4280 ;
    LAYER Poly ;
      RECT 3885 3080 3945 4280 ;
    LAYER Poly ;
      RECT 4165 3080 4225 4280 ;
    LAYER Poly ;
      RECT 1365 4280 4225 4490 ;
    LAYER Poly ;
      RECT 1365 2870 4225 3080 ;
    LAYER M7 ;
      RECT 0 4850 4145 5890 ;
    LAYER M7 ;
      RECT 1365 6710 4225 7410 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 1165 1470 4145 2000 ;
    LAYER M8 ;
      RECT 1365 6710 4225 7750 ;
    LAYER M8 ;
      RECT 1165 760 4145 2000 ;
    LAYER M9 ;
      RECT 1365 6530 4225 8530 ;
    LAYER M9 ;
      RECT 1165 0 4145 2000 ;
  END
END cas_mos2

MACRO bias1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias1 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END bias1
MACRO bias2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias2 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END bias2
MACRO bias_mos1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias_mos1 0 0 ;
  SIZE 2810 BY 2540 ;
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 220 2140 2590 2540 ;
    END
  END G
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M2 ;
        RECT 220 0 2590 450 ;
    END
  END D
  PIN BS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 2310 1150 2590 1390 ;
    END
  END BS
  OBS
    LAYER M2 ;
      RECT 220 0 2590 500 ;
    LAYER M2 ;
      RECT 1595 230 1775 1150 ;
    LAYER M2 ;
      RECT 1035 230 1215 1150 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M2 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 2040 2590 2540 ;
    LAYER M3 ;
      RECT 955 1665 1855 2175 ;
    LAYER M3 ;
      RECT 955 1485 1855 1665 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M4 ;
      RECT 490 1150 2485 1390 ;
    LAYER M4 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M4 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M4 ;
      RECT 755 1150 935 1390 ;
    LAYER M4 ;
      RECT 220 1150 500 1390 ;
    LAYER M4 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 1080 1150 1170 1390 ;
    LAYER M1 ;
      RECT 1360 1150 1450 1390 ;
    LAYER M1 ;
      RECT 1640 1150 1730 1390 ;
    LAYER M1 ;
      RECT 1920 1150 2010 1390 ;
    LAYER M1 ;
      RECT 800 1150 890 1390 ;
    LAYER M1 ;
      RECT 955 1485 1855 1665 ;
    LAYER M1 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M1 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M1 ;
      RECT 755 1150 935 1390 ;
    LAYER M1 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M1 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M1 ;
      RECT 220 710 500 1170 ;
    LAYER M1 ;
      RECT 2310 710 2590 1170 ;
    LAYER M1 ;
      RECT 220 1370 500 1830 ;
    LAYER M1 ;
      RECT 2310 1370 2590 1830 ;
    LAYER M1 ;
      RECT 220 500 2590 710 ;
    LAYER M1 ;
      RECT 220 1830 2590 2040 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 955 1530 1855 1620 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER Poly ;
      RECT 955 1470 1855 1680 ;
    LAYER Poly ;
      RECT 955 1030 1015 1170 ;
    LAYER Poly ;
      RECT 955 1370 1015 1470 ;
    LAYER Poly ;
      RECT 1235 1030 1295 1170 ;
    LAYER Poly ;
      RECT 1235 1370 1295 1470 ;
    LAYER Poly ;
      RECT 1515 1030 1575 1170 ;
    LAYER Poly ;
      RECT 1515 1370 1575 1470 ;
    LAYER Poly ;
      RECT 1795 1030 1855 1170 ;
    LAYER Poly ;
      RECT 1795 1370 1855 1470 ;
    LAYER Poly ;
      RECT 1795 1170 1855 1370 ;
    LAYER Poly ;
      RECT 1515 1170 1575 1370 ;
    LAYER Poly ;
      RECT 1235 1170 1295 1370 ;
    LAYER Poly ;
      RECT 955 1170 1015 1370 ;
  END
END bias_mos1
MACRO bias_mos2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias_mos2 0 0 ;
  SIZE 2810 BY 2540 ;
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 220 2140 2590 2540 ;
    END
  END G
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M2 ;
        RECT 220 0 2590 450 ;
    END
  END D
  PIN BS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 2310 1150 2590 1390 ;
    END
  END BS
  OBS
    LAYER M2 ;
      RECT 220 0 2590 500 ;
    LAYER M2 ;
      RECT 1595 230 1775 1150 ;
    LAYER M2 ;
      RECT 1035 230 1215 1150 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M2 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 2040 2590 2540 ;
    LAYER M3 ;
      RECT 955 1665 1855 2175 ;
    LAYER M3 ;
      RECT 955 1485 1855 1665 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M4 ;
      RECT 490 1150 2485 1390 ;
    LAYER M4 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M4 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M4 ;
      RECT 755 1150 935 1390 ;
    LAYER M4 ;
      RECT 220 1150 500 1390 ;
    LAYER M4 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 1080 1150 1170 1390 ;
    LAYER M1 ;
      RECT 1360 1150 1450 1390 ;
    LAYER M1 ;
      RECT 1640 1150 1730 1390 ;
    LAYER M1 ;
      RECT 1920 1150 2010 1390 ;
    LAYER M1 ;
      RECT 800 1150 890 1390 ;
    LAYER M1 ;
      RECT 955 1485 1855 1665 ;
    LAYER M1 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M1 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M1 ;
      RECT 755 1150 935 1390 ;
    LAYER M1 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M1 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M1 ;
      RECT 220 710 500 1170 ;
    LAYER M1 ;
      RECT 2310 710 2590 1170 ;
    LAYER M1 ;
      RECT 220 1370 500 1830 ;
    LAYER M1 ;
      RECT 2310 1370 2590 1830 ;
    LAYER M1 ;
      RECT 220 500 2590 710 ;
    LAYER M1 ;
      RECT 220 1830 2590 2040 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 955 1530 1855 1620 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER Poly ;
      RECT 955 1470 1855 1680 ;
    LAYER Poly ;
      RECT 955 1030 1015 1170 ;
    LAYER Poly ;
      RECT 955 1370 1015 1470 ;
    LAYER Poly ;
      RECT 1235 1030 1295 1170 ;
    LAYER Poly ;
      RECT 1235 1370 1295 1470 ;
    LAYER Poly ;
      RECT 1515 1030 1575 1170 ;
    LAYER Poly ;
      RECT 1515 1370 1575 1470 ;
    LAYER Poly ;
      RECT 1795 1030 1855 1170 ;
    LAYER Poly ;
      RECT 1795 1370 1855 1470 ;
    LAYER Poly ;
      RECT 1795 1170 1855 1370 ;
    LAYER Poly ;
      RECT 1515 1170 1575 1370 ;
    LAYER Poly ;
      RECT 1235 1170 1295 1370 ;
    LAYER Poly ;
      RECT 955 1170 1015 1370 ;
  END
END bias_mos2
MACRO cas_mos1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN cas_mos1 0 0 ;
  SIZE 5225 BY 8530 ;
  PIN SS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M7 ;
        RECT 0 4850 300 5890 ;
    END
  END SS
  PIN GG
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1365 7530 4225 8530 ;
    END
  END GG
  PIN DD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1165 0 4145 1000 ;
    END
  END DD
  PIN G2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 4725 2880 5225 4480 ;
    END
  END G2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 700 4368 910 4578 ;
    END
  END GND
  OBS
    LAYER M6 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 1365 6530 4225 6890 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 1165 1470 4145 2000 ;
    LAYER M1 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M1 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M1 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M1 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M1 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M1 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M1 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M1 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M1 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M1 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M1 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M1 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M1 ;
      RECT 1365 5990 4225 6170 ;
    LAYER M1 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M1 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M1 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M1 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M1 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M1 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M1 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M1 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M1 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M1 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M1 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M1 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M1 ;
      RECT 1365 4300 4225 4480 ;
    LAYER M1 ;
      RECT 1365 2880 4225 3060 ;
    LAYER M1 ;
      RECT 700 2510 4890 6540 ;
    LAYER M2 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M2 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M2 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M2 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M2 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M2 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M2 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M2 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M2 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M2 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M2 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M2 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M2 ;
      RECT 1365 5990 4225 6170 ;
    LAYER M2 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M2 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M2 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M2 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M2 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M2 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M2 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M2 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M2 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M2 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M2 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M2 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M2 ;
      RECT 1365 4300 4225 4480 ;
    LAYER M2 ;
      RECT 1365 2880 4225 3060 ;
    LAYER M3 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M3 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M3 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M3 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M3 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M3 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M3 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M3 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M3 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M3 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M3 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M3 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M3 ;
      RECT 1365 5990 4225 6170 ;
    LAYER M3 ;
      RECT 1365 6170 4225 6350 ;
    LAYER M3 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M3 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M3 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M3 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M3 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M3 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M3 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M3 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M3 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M3 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M3 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M3 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M3 ;
      RECT 1365 4300 4225 4480 ;
    LAYER M3 ;
      RECT 4225 4300 4725 4480 ;
    LAYER M3 ;
      RECT 1365 2880 4225 3060 ;
    LAYER M3 ;
      RECT 4225 2880 4725 3060 ;
    LAYER M3 ;
      RECT 4725 2880 5225 4480 ;
    LAYER M4 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M4 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M4 ;
      RECT 4245 4200 4425 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M4 ;
      RECT 1365 6170 4225 6530 ;
    LAYER M4 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M4 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M4 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M4 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M4 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M4 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M4 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M4 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M4 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M4 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M4 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M4 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M5 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M5 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M5 ;
      RECT 4245 4200 4425 5890 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M5 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M5 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M5 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M5 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M5 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M5 ;
      RECT 1365 6350 4225 6710 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 1165 1470 4145 2000 ;
    LAYER Poly ;
      RECT 1365 4730 1425 5970 ;
    LAYER Poly ;
      RECT 1645 4730 1705 5970 ;
    LAYER Poly ;
      RECT 1925 4730 1985 5970 ;
    LAYER Poly ;
      RECT 2205 4730 2265 5970 ;
    LAYER Poly ;
      RECT 2485 4730 2545 5970 ;
    LAYER Poly ;
      RECT 2765 4730 2825 5970 ;
    LAYER Poly ;
      RECT 3045 4730 3105 5970 ;
    LAYER Poly ;
      RECT 3325 4730 3385 5970 ;
    LAYER Poly ;
      RECT 3605 4730 3665 5970 ;
    LAYER Poly ;
      RECT 3885 4730 3945 5970 ;
    LAYER Poly ;
      RECT 4165 4730 4225 5970 ;
    LAYER Poly ;
      RECT 1365 5970 4225 6180 ;
    LAYER Poly ;
      RECT 1365 3080 1425 4280 ;
    LAYER Poly ;
      RECT 1645 3080 1705 4280 ;
    LAYER Poly ;
      RECT 1925 3080 1985 4280 ;
    LAYER Poly ;
      RECT 2205 3080 2265 4280 ;
    LAYER Poly ;
      RECT 2485 3080 2545 4280 ;
    LAYER Poly ;
      RECT 2765 3080 2825 4280 ;
    LAYER Poly ;
      RECT 3045 3080 3105 4280 ;
    LAYER Poly ;
      RECT 3325 3080 3385 4280 ;
    LAYER Poly ;
      RECT 3605 3080 3665 4280 ;
    LAYER Poly ;
      RECT 3885 3080 3945 4280 ;
    LAYER Poly ;
      RECT 4165 3080 4225 4280 ;
    LAYER Poly ;
      RECT 1365 4280 4225 4490 ;
    LAYER Poly ;
      RECT 1365 2870 4225 3080 ;
    LAYER M7 ;
      RECT 0 4850 4145 5890 ;
    LAYER M7 ;
      RECT 1365 6710 4225 7410 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 1165 1470 4145 2000 ;
    LAYER M8 ;
      RECT 1365 6710 4225 7750 ;
    LAYER M8 ;
      RECT 1165 760 4145 2000 ;
    LAYER M9 ;
      RECT 1365 6530 4225 8530 ;
    LAYER M9 ;
      RECT 1165 0 4145 2000 ;
  END
END cas_mos1
MACRO cas_mos2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN cas_mos2 0 0 ;
  SIZE 5225 BY 8530 ;
  PIN SS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M7 ;
        RECT 0 4850 300 5890 ;
    END
  END SS
  PIN GG
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1365 7530 4225 8530 ;
    END
  END GG
  PIN DD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1165 0 4145 1000 ;
    END
  END DD
  PIN G2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 4725 2880 5225 4480 ;
    END
  END G2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 700 4368 910 4578 ;
    END
  END GND
  OBS
    LAYER M6 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 1365 6530 4225 6890 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 1165 1470 4145 2000 ;
    LAYER M1 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M1 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M1 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M1 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M1 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M1 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M1 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M1 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M1 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M1 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M1 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M1 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M1 ;
      RECT 1365 5990 4225 6170 ;
    LAYER M1 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M1 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M1 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M1 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M1 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M1 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M1 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M1 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M1 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M1 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M1 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M1 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M1 ;
      RECT 1365 4300 4225 4480 ;
    LAYER M1 ;
      RECT 1365 2880 4225 3060 ;
    LAYER M1 ;
      RECT 700 2510 4890 6540 ;
    LAYER M2 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M2 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M2 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M2 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M2 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M2 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M2 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M2 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M2 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M2 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M2 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M2 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M2 ;
      RECT 1365 5990 4225 6170 ;
    LAYER M2 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M2 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M2 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M2 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M2 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M2 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M2 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M2 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M2 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M2 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M2 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M2 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M2 ;
      RECT 1365 4300 4225 4480 ;
    LAYER M2 ;
      RECT 1365 2880 4225 3060 ;
    LAYER M3 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M3 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M3 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M3 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M3 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M3 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M3 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M3 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M3 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M3 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M3 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M3 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M3 ;
      RECT 1365 5990 4225 6170 ;
    LAYER M3 ;
      RECT 1365 6170 4225 6350 ;
    LAYER M3 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M3 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M3 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M3 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M3 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M3 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M3 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M3 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M3 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M3 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M3 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M3 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M3 ;
      RECT 1365 4300 4225 4480 ;
    LAYER M3 ;
      RECT 4225 4300 4725 4480 ;
    LAYER M3 ;
      RECT 1365 2880 4225 3060 ;
    LAYER M3 ;
      RECT 4225 2880 4725 3060 ;
    LAYER M3 ;
      RECT 4725 2880 5225 4480 ;
    LAYER M4 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M4 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M4 ;
      RECT 4245 4200 4425 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M4 ;
      RECT 1365 6170 4225 6530 ;
    LAYER M4 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M4 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M4 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M4 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M4 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M4 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M4 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M4 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M4 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M4 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M4 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M4 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M5 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M5 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M5 ;
      RECT 4245 4200 4425 5890 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M5 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M5 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M5 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M5 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M5 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M5 ;
      RECT 1365 6350 4225 6710 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 1165 1470 4145 2000 ;
    LAYER Poly ;
      RECT 1365 4730 1425 5970 ;
    LAYER Poly ;
      RECT 1645 4730 1705 5970 ;
    LAYER Poly ;
      RECT 1925 4730 1985 5970 ;
    LAYER Poly ;
      RECT 2205 4730 2265 5970 ;
    LAYER Poly ;
      RECT 2485 4730 2545 5970 ;
    LAYER Poly ;
      RECT 2765 4730 2825 5970 ;
    LAYER Poly ;
      RECT 3045 4730 3105 5970 ;
    LAYER Poly ;
      RECT 3325 4730 3385 5970 ;
    LAYER Poly ;
      RECT 3605 4730 3665 5970 ;
    LAYER Poly ;
      RECT 3885 4730 3945 5970 ;
    LAYER Poly ;
      RECT 4165 4730 4225 5970 ;
    LAYER Poly ;
      RECT 1365 5970 4225 6180 ;
    LAYER Poly ;
      RECT 1365 3080 1425 4280 ;
    LAYER Poly ;
      RECT 1645 3080 1705 4280 ;
    LAYER Poly ;
      RECT 1925 3080 1985 4280 ;
    LAYER Poly ;
      RECT 2205 3080 2265 4280 ;
    LAYER Poly ;
      RECT 2485 3080 2545 4280 ;
    LAYER Poly ;
      RECT 2765 3080 2825 4280 ;
    LAYER Poly ;
      RECT 3045 3080 3105 4280 ;
    LAYER Poly ;
      RECT 3325 3080 3385 4280 ;
    LAYER Poly ;
      RECT 3605 3080 3665 4280 ;
    LAYER Poly ;
      RECT 3885 3080 3945 4280 ;
    LAYER Poly ;
      RECT 4165 3080 4225 4280 ;
    LAYER Poly ;
      RECT 1365 4280 4225 4490 ;
    LAYER Poly ;
      RECT 1365 2870 4225 3080 ;
    LAYER M7 ;
      RECT 0 4850 4145 5890 ;
    LAYER M7 ;
      RECT 1365 6710 4225 7410 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 1165 1470 4145 2000 ;
    LAYER M8 ;
      RECT 1365 6710 4225 7750 ;
    LAYER M8 ;
      RECT 1165 760 4145 2000 ;
    LAYER M9 ;
      RECT 1365 6530 4225 8530 ;
    LAYER M9 ;
      RECT 1165 0 4145 2000 ;
  END
END cas_mos2
MACRO drain_ind1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN drain_ind1 0 0 ;
  SIZE 110000 BY 42000 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 2000 22000 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 108000 20000 110000 22000 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 110000 22000 ;
    LAYER M1 ;
      RECT 2000 0 108000 42000 ;
  END
END drain_ind1
MACRO drain_ind2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN drain_ind2 0 0 ;
  SIZE 85000 BY 43000 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 3000 23000 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 82000 20000 85000 23000 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 85000 23000 ;
    LAYER M1 ;
      RECT 3000 0 82000 43000 ;
  END
END drain_ind2
MACRO gate_ind_x.25
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gate_ind_x.25 0 0 ;
  SIZE 126482 BY 128482 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 121982 57487 126482 61987 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 57487 123982 61987 128482 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 108982 54737 118982 64737 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 73732 57487 102232 61987 ;
    LAYER M8 ;
      RECT 0 0 119474 119474 ;
    LAYER M9 ;
      RECT 97732 57487 126482 61987 ;
    LAYER M9 ;
      RECT 25242 23242 94232 96232 ;
    LAYER M9 ;
      RECT 57487 91732 61987 128482 ;
    LAYER M9 ;
      RECT 0 0 119474 119474 ;
    LAYER M1 ;
      RECT 0 0 119474 119474 ;
    LAYER M2 ;
      RECT 0 0 119474 119474 ;
    LAYER M3 ;
      RECT 0 0 119474 119474 ;
    LAYER M4 ;
      RECT 0 0 119474 119474 ;
    LAYER M5 ;
      RECT 0 0 119474 119474 ;
    LAYER M6 ;
      RECT 0 0 119474 119474 ;
    LAYER M7 ;
      RECT 0 0 119474 119474 ;
  END
END gate_ind_x.25
MACRO gnd0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gnd0 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END gnd0
MACRO gnd1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gnd1 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END gnd1
MACRO input
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN input 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END input
MACRO source_ind
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN source_ind 0 0 ;
  SIZE 75000 BY 48500 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 8500 28500 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 66500 20000 75000 28500 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 75000 28500 ;
    LAYER M1 ;
      RECT 8500 0 66500 48500 ;
  END
END source_ind
MACRO vdd1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN vdd1 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END vdd1
MACRO vdd2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN vdd2 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END vdd2
MACRO xCs_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xCs_1 0 0 ;
  SIZE 16840 BY 11840 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6818 11410 10022 11840 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6818 0 10022 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 4740 1660 7100 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 15180 1760 16840 10080 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 7940 14340 11840 ;
    LAYER M8 ;
      RECT 2500 0 14340 3900 ;
    LAYER M8 ;
      RECT 14340 10180 16840 11840 ;
    LAYER M8 ;
      RECT 14340 0 16840 1660 ;
    LAYER M8 ;
      RECT 15180 0 16840 11840 ;
    LAYER M8 ;
      RECT 0 4740 14340 7100 ;
    LAYER M8 ;
      RECT 5000 7100 6740 9340 ;
    LAYER M8 ;
      RECT 5000 7100 6740 9340 ;
    LAYER M8 ;
      RECT 5000 2500 6740 4740 ;
    LAYER M8 ;
      RECT 10100 7100 11840 9340 ;
    LAYER M8 ;
      RECT 10100 7100 11840 9340 ;
    LAYER M8 ;
      RECT 10100 2500 11840 4740 ;
    LAYER M5 ;
      RECT 7820 0 9020 11840 ;
    LAYER M5 ;
      RECT 2500 5320 14340 6520 ;
    LAYER M5 ;
      RECT 9620 7720 10820 11840 ;
    LAYER M5 ;
      RECT 9620 7120 14340 8320 ;
    LAYER M5 ;
      RECT 11420 9520 12620 11840 ;
    LAYER M5 ;
      RECT 11420 8920 14340 10120 ;
    LAYER M5 ;
      RECT 13220 11320 14340 11840 ;
    LAYER M5 ;
      RECT 13220 10720 14340 11840 ;
    LAYER M5 ;
      RECT 6020 7720 7220 11840 ;
    LAYER M5 ;
      RECT 2500 7120 7220 8320 ;
    LAYER M5 ;
      RECT 4220 9520 5420 11840 ;
    LAYER M5 ;
      RECT 2500 8920 5420 10120 ;
    LAYER M5 ;
      RECT 2500 11320 3620 11840 ;
    LAYER M5 ;
      RECT 2500 10720 3620 11840 ;
    LAYER M5 ;
      RECT 6020 0 7220 4120 ;
    LAYER M5 ;
      RECT 2500 3520 7220 4720 ;
    LAYER M5 ;
      RECT 4220 0 5420 2320 ;
    LAYER M5 ;
      RECT 2500 1720 5420 2920 ;
    LAYER M5 ;
      RECT 2500 0 3620 520 ;
    LAYER M5 ;
      RECT 2500 0 3620 1120 ;
    LAYER M5 ;
      RECT 9620 0 10820 4120 ;
    LAYER M5 ;
      RECT 9620 3520 14340 4720 ;
    LAYER M5 ;
      RECT 11420 0 12620 2320 ;
    LAYER M5 ;
      RECT 11420 1720 14340 2920 ;
    LAYER M5 ;
      RECT 13220 0 14340 520 ;
    LAYER M5 ;
      RECT 13220 0 14340 1120 ;
    LAYER M5 ;
      RECT 2500 11410 14340 11840 ;
    LAYER M5 ;
      RECT 2500 0 14340 430 ;
    LAYER M6 ;
      RECT 8720 6820 9920 11840 ;
    LAYER M6 ;
      RECT 8720 6220 14340 7420 ;
    LAYER M6 ;
      RECT 10520 8620 11720 11840 ;
    LAYER M6 ;
      RECT 10520 8020 14340 9220 ;
    LAYER M6 ;
      RECT 12320 10420 13520 11840 ;
    LAYER M6 ;
      RECT 12320 9820 14340 11020 ;
    LAYER M6 ;
      RECT 6920 6820 8120 11840 ;
    LAYER M6 ;
      RECT 2500 6220 8120 7420 ;
    LAYER M6 ;
      RECT 5120 8620 6320 11840 ;
    LAYER M6 ;
      RECT 2500 8020 6320 9220 ;
    LAYER M6 ;
      RECT 3320 10420 4520 11840 ;
    LAYER M6 ;
      RECT 2500 9820 4520 11020 ;
    LAYER M6 ;
      RECT 6920 0 8120 5020 ;
    LAYER M6 ;
      RECT 2500 4420 8120 5620 ;
    LAYER M6 ;
      RECT 5120 0 6320 3220 ;
    LAYER M6 ;
      RECT 2500 2620 6320 3820 ;
    LAYER M6 ;
      RECT 3320 0 4520 1420 ;
    LAYER M6 ;
      RECT 2500 820 4520 2020 ;
    LAYER M6 ;
      RECT 8720 0 9920 5020 ;
    LAYER M6 ;
      RECT 8720 4420 14340 5620 ;
    LAYER M6 ;
      RECT 10520 0 11720 3220 ;
    LAYER M6 ;
      RECT 10520 2620 14340 3820 ;
    LAYER M6 ;
      RECT 12320 0 13520 1420 ;
    LAYER M6 ;
      RECT 12320 820 14340 2020 ;
    LAYER M6 ;
      RECT 2500 11410 14340 11840 ;
    LAYER M6 ;
      RECT 2500 0 14340 430 ;
  END
END xCs_1
MACRO xR00_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR00_0 0 0 ;
  SIZE 9830 BY 3750 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 3530 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 9510 220 9600 3530 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 9630 3530 ;
    LAYER RPO ;
      RECT 540 0 9290 3750 ;
    LAYER M1 ;
      RECT 230 235 320 3515 ;
    LAYER M1 ;
      RECT 9510 235 9600 3515 ;
    LAYER RH ;
      RECT 0 20 9830 3730 ;
  END
END xR00_0
MACRO xR0_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR0_2 0 0 ;
  SIZE 25540 BY 7840 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 7620 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 25220 220 25310 7620 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 25340 7620 ;
    LAYER RPO ;
      RECT 540 0 25000 7840 ;
    LAYER M1 ;
      RECT 230 235 320 7605 ;
    LAYER M1 ;
      RECT 25220 235 25310 7605 ;
    LAYER RH ;
      RECT 0 20 25540 7820 ;
  END
END xR0_2
MACRO xR11_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR11_2 0 0 ;
  SIZE 16790 BY 4400 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4180 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 16470 220 16560 4180 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 16590 4180 ;
    LAYER RPO ;
      RECT 540 0 16250 4400 ;
    LAYER M1 ;
      RECT 230 235 320 4165 ;
    LAYER M1 ;
      RECT 16470 235 16560 4165 ;
    LAYER RH ;
      RECT 0 20 16790 4380 ;
  END
END xR11_2
MACRO xR1_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR1_2 0 0 ;
  SIZE 16790 BY 4400 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4180 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 16470 220 16560 4180 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 16590 4180 ;
    LAYER RPO ;
      RECT 540 0 16250 4400 ;
    LAYER M1 ;
      RECT 230 235 320 4165 ;
    LAYER M1 ;
      RECT 16470 235 16560 4165 ;
    LAYER RH ;
      RECT 0 20 16790 4380 ;
  END
END xR1_2
MACRO xR22_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR22_0 0 0 ;
  SIZE 4070 BY 4960 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4740 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 3750 220 3840 4740 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 3870 4740 ;
    LAYER RPO ;
      RECT 540 0 3530 4960 ;
    LAYER M1 ;
      RECT 230 235 320 4725 ;
    LAYER M1 ;
      RECT 3750 235 3840 4725 ;
    LAYER RH ;
      RECT 0 20 4070 4940 ;
  END
END xR22_0
MACRO xR2_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR2_0 0 0 ;
  SIZE 4070 BY 4960 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4740 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 3750 220 3840 4740 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 3870 4740 ;
    LAYER RPO ;
      RECT 540 0 3530 4960 ;
    LAYER M1 ;
      RECT 230 235 320 4725 ;
    LAYER M1 ;
      RECT 3750 235 3840 4725 ;
    LAYER RH ;
      RECT 0 20 4070 4940 ;
  END
END xR2_0
MACRO xR33_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR33_2 0 0 ;
  SIZE 16790 BY 4400 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4180 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 16470 220 16560 4180 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 16590 4180 ;
    LAYER RPO ;
      RECT 540 0 16250 4400 ;
    LAYER M1 ;
      RECT 230 235 320 4165 ;
    LAYER M1 ;
      RECT 16470 235 16560 4165 ;
    LAYER RH ;
      RECT 0 20 16790 4380 ;
  END
END xR33_2
MACRO xR3_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR3_2 0 0 ;
  SIZE 16790 BY 4400 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4180 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 16470 220 16560 4180 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 16590 4180 ;
    LAYER RPO ;
      RECT 540 0 16250 4400 ;
    LAYER M1 ;
      RECT 230 235 320 4165 ;
    LAYER M1 ;
      RECT 16470 235 16560 4165 ;
    LAYER RH ;
      RECT 0 20 16790 4380 ;
  END
END xR3_2
MACRO xc1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc1_1 0 0 ;
  SIZE 8170 BY 9610 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 9510 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 6890 4075 8170 5535 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 8050 6490 9510 ;
    LAYER M8 ;
      RECT 0 100 6490 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 8050 ;
    LAYER M8 ;
      RECT 1680 4075 8170 5535 ;
    LAYER M8 ;
      RECT 1820 2540 3280 7070 ;
    LAYER M8 ;
      RECT 4890 2540 6350 7070 ;
  END
END xc1_1
MACRO xc2_3
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc2_3 0 0 ;
  SIZE 18640 BY 33870 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 7418 33440 11222 33870 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 7418 0 11222 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 15755 1660 18115 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 16980 11875 18640 21995 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 18955 16140 33870 ;
    LAYER M8 ;
      RECT 2500 0 16140 14915 ;
    LAYER M8 ;
      RECT 16140 32210 18640 33870 ;
    LAYER M8 ;
      RECT 16140 0 18640 1660 ;
    LAYER M8 ;
      RECT 16980 0 18640 33870 ;
    LAYER M8 ;
      RECT 0 15755 16140 18115 ;
    LAYER M8 ;
      RECT 5000 18115 6740 31370 ;
    LAYER M8 ;
      RECT 5000 18115 6740 31370 ;
    LAYER M8 ;
      RECT 5000 2500 6740 15755 ;
    LAYER M8 ;
      RECT 8450 18115 10190 31370 ;
    LAYER M8 ;
      RECT 8450 18115 10190 31370 ;
    LAYER M8 ;
      RECT 8450 2500 10190 15755 ;
    LAYER M8 ;
      RECT 11900 18115 13640 31370 ;
    LAYER M8 ;
      RECT 11900 18115 13640 31370 ;
    LAYER M8 ;
      RECT 11900 2500 13640 15755 ;
    LAYER M5 ;
      RECT 8720 0 9920 33870 ;
    LAYER M5 ;
      RECT 2500 16335 16140 17535 ;
    LAYER M5 ;
      RECT 10520 18735 11720 33870 ;
    LAYER M5 ;
      RECT 10520 18135 16140 19335 ;
    LAYER M5 ;
      RECT 12320 20535 13520 33870 ;
    LAYER M5 ;
      RECT 12320 19935 16140 21135 ;
    LAYER M5 ;
      RECT 14120 22335 15320 33870 ;
    LAYER M5 ;
      RECT 14120 21735 16140 22935 ;
    LAYER M5 ;
      RECT 15920 24135 16140 33870 ;
    LAYER M5 ;
      RECT 15920 23535 16140 24735 ;
    LAYER M5 ;
      RECT 6920 18735 8120 33870 ;
    LAYER M5 ;
      RECT 2500 18135 8120 19335 ;
    LAYER M5 ;
      RECT 5120 20535 6320 33870 ;
    LAYER M5 ;
      RECT 2500 19935 6320 21135 ;
    LAYER M5 ;
      RECT 3320 22335 4520 33870 ;
    LAYER M5 ;
      RECT 2500 21735 4520 22935 ;
    LAYER M5 ;
      RECT 2500 24135 2720 33870 ;
    LAYER M5 ;
      RECT 2500 23535 2720 24735 ;
    LAYER M5 ;
      RECT 6920 0 8120 15135 ;
    LAYER M5 ;
      RECT 2500 14535 8120 15735 ;
    LAYER M5 ;
      RECT 5120 0 6320 13335 ;
    LAYER M5 ;
      RECT 2500 12735 6320 13935 ;
    LAYER M5 ;
      RECT 3320 0 4520 11535 ;
    LAYER M5 ;
      RECT 2500 10935 4520 12135 ;
    LAYER M5 ;
      RECT 2500 0 2720 9735 ;
    LAYER M5 ;
      RECT 2500 9135 2720 10335 ;
    LAYER M5 ;
      RECT 10520 0 11720 15135 ;
    LAYER M5 ;
      RECT 10520 14535 16140 15735 ;
    LAYER M5 ;
      RECT 12320 0 13520 13335 ;
    LAYER M5 ;
      RECT 12320 12735 16140 13935 ;
    LAYER M5 ;
      RECT 14120 0 15320 11535 ;
    LAYER M5 ;
      RECT 14120 10935 16140 12135 ;
    LAYER M5 ;
      RECT 15920 0 16140 9735 ;
    LAYER M5 ;
      RECT 15920 9135 16140 10335 ;
    LAYER M5 ;
      RECT 2500 33440 16140 33870 ;
    LAYER M5 ;
      RECT 2500 0 16140 430 ;
    LAYER M6 ;
      RECT 9620 17835 10820 33870 ;
    LAYER M6 ;
      RECT 9620 17235 16140 18435 ;
    LAYER M6 ;
      RECT 11420 19635 12620 33870 ;
    LAYER M6 ;
      RECT 11420 19035 16140 20235 ;
    LAYER M6 ;
      RECT 13220 21435 14420 33870 ;
    LAYER M6 ;
      RECT 13220 20835 16140 22035 ;
    LAYER M6 ;
      RECT 15020 23235 16140 33870 ;
    LAYER M6 ;
      RECT 15020 22635 16140 23835 ;
    LAYER M6 ;
      RECT 7820 17835 9020 33870 ;
    LAYER M6 ;
      RECT 2500 17235 9020 18435 ;
    LAYER M6 ;
      RECT 6020 19635 7220 33870 ;
    LAYER M6 ;
      RECT 2500 19035 7220 20235 ;
    LAYER M6 ;
      RECT 4220 21435 5420 33870 ;
    LAYER M6 ;
      RECT 2500 20835 5420 22035 ;
    LAYER M6 ;
      RECT 2500 23235 3620 33870 ;
    LAYER M6 ;
      RECT 2500 22635 3620 23835 ;
    LAYER M6 ;
      RECT 7820 0 9020 16035 ;
    LAYER M6 ;
      RECT 2500 15435 9020 16635 ;
    LAYER M6 ;
      RECT 6020 0 7220 14235 ;
    LAYER M6 ;
      RECT 2500 13635 7220 14835 ;
    LAYER M6 ;
      RECT 4220 0 5420 12435 ;
    LAYER M6 ;
      RECT 2500 11835 5420 13035 ;
    LAYER M6 ;
      RECT 2500 0 3620 10635 ;
    LAYER M6 ;
      RECT 2500 10035 3620 11235 ;
    LAYER M6 ;
      RECT 9620 0 10820 16035 ;
    LAYER M6 ;
      RECT 9620 15435 16140 16635 ;
    LAYER M6 ;
      RECT 11420 0 12620 14235 ;
    LAYER M6 ;
      RECT 11420 13635 16140 14835 ;
    LAYER M6 ;
      RECT 13220 0 14420 12435 ;
    LAYER M6 ;
      RECT 13220 11835 16140 13035 ;
    LAYER M6 ;
      RECT 15020 0 16140 10635 ;
    LAYER M6 ;
      RECT 15020 10035 16140 11235 ;
    LAYER M6 ;
      RECT 2500 33440 16140 33870 ;
    LAYER M6 ;
      RECT 2500 0 16140 430 ;
  END
END xc2_3
MACRO xc33_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc33_1 0 0 ;
  SIZE 20660 BY 15660 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 15230 12568 15660 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 0 12568 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 6650 1660 9010 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 19000 1760 20660 13900 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 9850 18160 15660 ;
    LAYER M8 ;
      RECT 2500 0 18160 5810 ;
    LAYER M8 ;
      RECT 18160 14000 20660 15660 ;
    LAYER M8 ;
      RECT 18160 0 20660 1660 ;
    LAYER M8 ;
      RECT 19000 0 20660 15660 ;
    LAYER M8 ;
      RECT 0 6650 18160 9010 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 2500 6740 6650 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 2500 9713 6650 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 2500 12687 6650 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 2500 15660 6650 ;
    LAYER M5 ;
      RECT 9730 0 10930 15660 ;
    LAYER M5 ;
      RECT 2500 7230 18160 8430 ;
    LAYER M5 ;
      RECT 11530 9630 12730 15660 ;
    LAYER M5 ;
      RECT 11530 9030 18160 10230 ;
    LAYER M5 ;
      RECT 13330 11430 14530 15660 ;
    LAYER M5 ;
      RECT 13330 10830 18160 12030 ;
    LAYER M5 ;
      RECT 15130 13230 16330 15660 ;
    LAYER M5 ;
      RECT 15130 12630 18160 13830 ;
    LAYER M5 ;
      RECT 16930 15030 18130 15660 ;
    LAYER M5 ;
      RECT 16930 14430 18160 15630 ;
    LAYER M5 ;
      RECT 7930 9630 9130 15660 ;
    LAYER M5 ;
      RECT 2500 9030 9130 10230 ;
    LAYER M5 ;
      RECT 6130 11430 7330 15660 ;
    LAYER M5 ;
      RECT 2500 10830 7330 12030 ;
    LAYER M5 ;
      RECT 4330 13230 5530 15660 ;
    LAYER M5 ;
      RECT 2500 12630 5530 13830 ;
    LAYER M5 ;
      RECT 2530 15030 3730 15660 ;
    LAYER M5 ;
      RECT 2500 14430 3730 15630 ;
    LAYER M5 ;
      RECT 7930 0 9130 6030 ;
    LAYER M5 ;
      RECT 2500 5430 9130 6630 ;
    LAYER M5 ;
      RECT 6130 0 7330 4230 ;
    LAYER M5 ;
      RECT 2500 3630 7330 4830 ;
    LAYER M5 ;
      RECT 4330 0 5530 2430 ;
    LAYER M5 ;
      RECT 2500 1830 5530 3030 ;
    LAYER M5 ;
      RECT 2530 0 3730 630 ;
    LAYER M5 ;
      RECT 2500 30 3730 1230 ;
    LAYER M5 ;
      RECT 11530 0 12730 6030 ;
    LAYER M5 ;
      RECT 11530 5430 18160 6630 ;
    LAYER M5 ;
      RECT 13330 0 14530 4230 ;
    LAYER M5 ;
      RECT 13330 3630 18160 4830 ;
    LAYER M5 ;
      RECT 15130 0 16330 2430 ;
    LAYER M5 ;
      RECT 15130 1830 18160 3030 ;
    LAYER M5 ;
      RECT 16930 0 18130 630 ;
    LAYER M5 ;
      RECT 16930 30 18160 1230 ;
    LAYER M5 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M5 ;
      RECT 2500 0 18160 430 ;
    LAYER M6 ;
      RECT 10630 8730 11830 15660 ;
    LAYER M6 ;
      RECT 10630 8130 18160 9330 ;
    LAYER M6 ;
      RECT 12430 10530 13630 15660 ;
    LAYER M6 ;
      RECT 12430 9930 18160 11130 ;
    LAYER M6 ;
      RECT 14230 12330 15430 15660 ;
    LAYER M6 ;
      RECT 14230 11730 18160 12930 ;
    LAYER M6 ;
      RECT 16030 14130 17230 15660 ;
    LAYER M6 ;
      RECT 16030 13530 18160 14730 ;
    LAYER M6 ;
      RECT 8830 8730 10030 15660 ;
    LAYER M6 ;
      RECT 2500 8130 10030 9330 ;
    LAYER M6 ;
      RECT 7030 10530 8230 15660 ;
    LAYER M6 ;
      RECT 2500 9930 8230 11130 ;
    LAYER M6 ;
      RECT 5230 12330 6430 15660 ;
    LAYER M6 ;
      RECT 2500 11730 6430 12930 ;
    LAYER M6 ;
      RECT 3430 14130 4630 15660 ;
    LAYER M6 ;
      RECT 2500 13530 4630 14730 ;
    LAYER M6 ;
      RECT 8830 0 10030 6930 ;
    LAYER M6 ;
      RECT 2500 6330 10030 7530 ;
    LAYER M6 ;
      RECT 7030 0 8230 5130 ;
    LAYER M6 ;
      RECT 2500 4530 8230 5730 ;
    LAYER M6 ;
      RECT 5230 0 6430 3330 ;
    LAYER M6 ;
      RECT 2500 2730 6430 3930 ;
    LAYER M6 ;
      RECT 3430 0 4630 1530 ;
    LAYER M6 ;
      RECT 2500 930 4630 2130 ;
    LAYER M6 ;
      RECT 10630 0 11830 6930 ;
    LAYER M6 ;
      RECT 10630 6330 18160 7530 ;
    LAYER M6 ;
      RECT 12430 0 13630 5130 ;
    LAYER M6 ;
      RECT 12430 4530 18160 5730 ;
    LAYER M6 ;
      RECT 14230 0 15430 3330 ;
    LAYER M6 ;
      RECT 14230 2730 18160 3930 ;
    LAYER M6 ;
      RECT 16030 0 17230 1530 ;
    LAYER M6 ;
      RECT 16030 930 18160 2130 ;
    LAYER M6 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M6 ;
      RECT 2500 0 18160 430 ;
  END
END xc33_1
MACRO xc3_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc3_1 0 0 ;
  SIZE 20660 BY 15660 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 15230 12568 15660 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 0 12568 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 6650 1660 9010 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 19000 1760 20660 13900 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 9850 18160 15660 ;
    LAYER M8 ;
      RECT 2500 0 18160 5810 ;
    LAYER M8 ;
      RECT 18160 14000 20660 15660 ;
    LAYER M8 ;
      RECT 18160 0 20660 1660 ;
    LAYER M8 ;
      RECT 19000 0 20660 15660 ;
    LAYER M8 ;
      RECT 0 6650 18160 9010 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 2500 6740 6650 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 2500 9713 6650 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 2500 12687 6650 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 2500 15660 6650 ;
    LAYER M5 ;
      RECT 9730 0 10930 15660 ;
    LAYER M5 ;
      RECT 2500 7230 18160 8430 ;
    LAYER M5 ;
      RECT 11530 9630 12730 15660 ;
    LAYER M5 ;
      RECT 11530 9030 18160 10230 ;
    LAYER M5 ;
      RECT 13330 11430 14530 15660 ;
    LAYER M5 ;
      RECT 13330 10830 18160 12030 ;
    LAYER M5 ;
      RECT 15130 13230 16330 15660 ;
    LAYER M5 ;
      RECT 15130 12630 18160 13830 ;
    LAYER M5 ;
      RECT 16930 15030 18130 15660 ;
    LAYER M5 ;
      RECT 16930 14430 18160 15630 ;
    LAYER M5 ;
      RECT 7930 9630 9130 15660 ;
    LAYER M5 ;
      RECT 2500 9030 9130 10230 ;
    LAYER M5 ;
      RECT 6130 11430 7330 15660 ;
    LAYER M5 ;
      RECT 2500 10830 7330 12030 ;
    LAYER M5 ;
      RECT 4330 13230 5530 15660 ;
    LAYER M5 ;
      RECT 2500 12630 5530 13830 ;
    LAYER M5 ;
      RECT 2530 15030 3730 15660 ;
    LAYER M5 ;
      RECT 2500 14430 3730 15630 ;
    LAYER M5 ;
      RECT 7930 0 9130 6030 ;
    LAYER M5 ;
      RECT 2500 5430 9130 6630 ;
    LAYER M5 ;
      RECT 6130 0 7330 4230 ;
    LAYER M5 ;
      RECT 2500 3630 7330 4830 ;
    LAYER M5 ;
      RECT 4330 0 5530 2430 ;
    LAYER M5 ;
      RECT 2500 1830 5530 3030 ;
    LAYER M5 ;
      RECT 2530 0 3730 630 ;
    LAYER M5 ;
      RECT 2500 30 3730 1230 ;
    LAYER M5 ;
      RECT 11530 0 12730 6030 ;
    LAYER M5 ;
      RECT 11530 5430 18160 6630 ;
    LAYER M5 ;
      RECT 13330 0 14530 4230 ;
    LAYER M5 ;
      RECT 13330 3630 18160 4830 ;
    LAYER M5 ;
      RECT 15130 0 16330 2430 ;
    LAYER M5 ;
      RECT 15130 1830 18160 3030 ;
    LAYER M5 ;
      RECT 16930 0 18130 630 ;
    LAYER M5 ;
      RECT 16930 30 18160 1230 ;
    LAYER M5 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M5 ;
      RECT 2500 0 18160 430 ;
    LAYER M6 ;
      RECT 10630 8730 11830 15660 ;
    LAYER M6 ;
      RECT 10630 8130 18160 9330 ;
    LAYER M6 ;
      RECT 12430 10530 13630 15660 ;
    LAYER M6 ;
      RECT 12430 9930 18160 11130 ;
    LAYER M6 ;
      RECT 14230 12330 15430 15660 ;
    LAYER M6 ;
      RECT 14230 11730 18160 12930 ;
    LAYER M6 ;
      RECT 16030 14130 17230 15660 ;
    LAYER M6 ;
      RECT 16030 13530 18160 14730 ;
    LAYER M6 ;
      RECT 8830 8730 10030 15660 ;
    LAYER M6 ;
      RECT 2500 8130 10030 9330 ;
    LAYER M6 ;
      RECT 7030 10530 8230 15660 ;
    LAYER M6 ;
      RECT 2500 9930 8230 11130 ;
    LAYER M6 ;
      RECT 5230 12330 6430 15660 ;
    LAYER M6 ;
      RECT 2500 11730 6430 12930 ;
    LAYER M6 ;
      RECT 3430 14130 4630 15660 ;
    LAYER M6 ;
      RECT 2500 13530 4630 14730 ;
    LAYER M6 ;
      RECT 8830 0 10030 6930 ;
    LAYER M6 ;
      RECT 2500 6330 10030 7530 ;
    LAYER M6 ;
      RECT 7030 0 8230 5130 ;
    LAYER M6 ;
      RECT 2500 4530 8230 5730 ;
    LAYER M6 ;
      RECT 5230 0 6430 3330 ;
    LAYER M6 ;
      RECT 2500 2730 6430 3930 ;
    LAYER M6 ;
      RECT 3430 0 4630 1530 ;
    LAYER M6 ;
      RECT 2500 930 4630 2130 ;
    LAYER M6 ;
      RECT 10630 0 11830 6930 ;
    LAYER M6 ;
      RECT 10630 6330 18160 7530 ;
    LAYER M6 ;
      RECT 12430 0 13630 5130 ;
    LAYER M6 ;
      RECT 12430 4530 18160 5730 ;
    LAYER M6 ;
      RECT 14230 0 15430 3330 ;
    LAYER M6 ;
      RECT 14230 2730 18160 3930 ;
    LAYER M6 ;
      RECT 16030 0 17230 1530 ;
    LAYER M6 ;
      RECT 16030 930 18160 2130 ;
    LAYER M6 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M6 ;
      RECT 2500 0 18160 430 ;
  END
END xc3_1
MACRO xwg1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xwg1 0 0 ;
  SIZE 65000 BY 36210 ;
  PIN GND1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 27765 1000 37235 9470 ;
    END
  END GND1
  PIN GND2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 27765 26740 37235 35210 ;
    END
  END GND2
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 2180 13370 11650 22840 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 53350 13370 62820 22840 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 2180 13370 62820 22840 ;
    LAYER M9 ;
      RECT 2180 26740 62820 35210 ;
    LAYER M9 ;
      RECT 2180 1000 62820 9470 ;
    LAYER M9 ;
      RECT 0 33310 65000 36210 ;
    LAYER M9 ;
      RECT 0 0 65000 2900 ;
    LAYER M8 ;
      RECT 0 33310 65000 36210 ;
    LAYER M8 ;
      RECT 0 0 65000 2900 ;
    LAYER M8 ;
      RECT 0 0 2000 36210 ;
    LAYER M8 ;
      RECT 3000 0 5000 36210 ;
    LAYER M8 ;
      RECT 6000 0 8000 36210 ;
    LAYER M8 ;
      RECT 9000 0 11000 36210 ;
    LAYER M8 ;
      RECT 12000 0 14000 36210 ;
    LAYER M8 ;
      RECT 15000 0 17000 36210 ;
    LAYER M8 ;
      RECT 18000 0 20000 36210 ;
    LAYER M8 ;
      RECT 21000 0 23000 36210 ;
    LAYER M8 ;
      RECT 24000 0 26000 36210 ;
    LAYER M8 ;
      RECT 27000 0 29000 36210 ;
    LAYER M8 ;
      RECT 30000 0 32000 36210 ;
    LAYER M8 ;
      RECT 33000 0 35000 36210 ;
    LAYER M8 ;
      RECT 36000 0 38000 36210 ;
    LAYER M8 ;
      RECT 39000 0 41000 36210 ;
    LAYER M8 ;
      RECT 42000 0 44000 36210 ;
    LAYER M8 ;
      RECT 45000 0 47000 36210 ;
    LAYER M8 ;
      RECT 48000 0 50000 36210 ;
    LAYER M8 ;
      RECT 51000 0 53000 36210 ;
    LAYER M8 ;
      RECT 54000 0 56000 36210 ;
    LAYER M8 ;
      RECT 57000 0 59000 36210 ;
    LAYER M8 ;
      RECT 60000 0 62000 36210 ;
    LAYER M8 ;
      RECT 63000 0 65000 36210 ;
  END
END xwg1

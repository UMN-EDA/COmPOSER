MACRO xR00_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR00_0 0 0 ;
  SIZE 9830 BY 3750 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 3530 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 9510 220 9600 3530 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 9630 3530 ;
    LAYER RPO ;
      RECT 540 0 9290 3750 ;
    LAYER M1 ;
      RECT 230 235 320 3515 ;
    LAYER M1 ;
      RECT 9510 235 9600 3515 ;
    LAYER RH ;
      RECT 0 20 9830 3730 ;
  END
END xR00_0

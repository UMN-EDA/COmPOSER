MACRO xR22_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR22_0 0 0 ;
  SIZE 4070 BY 4960 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4740 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 3750 220 3840 4740 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 3870 4740 ;
    LAYER RPO ;
      RECT 540 0 3530 4960 ;
    LAYER M1 ;
      RECT 230 235 320 4725 ;
    LAYER M1 ;
      RECT 3750 235 3840 4725 ;
    LAYER RH ;
      RECT 0 20 4070 4940 ;
  END
END xR22_0

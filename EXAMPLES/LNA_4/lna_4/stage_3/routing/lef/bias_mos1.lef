MACRO bias_mos1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias_mos1 0 0 ;
  SIZE 2810 BY 2540 ;
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 220 2140 2590 2540 ;
    END
  END G
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M2 ;
        RECT 220 0 2590 450 ;
    END
  END D
  PIN BS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 2310 1150 2590 1390 ;
    END
  END BS
  OBS
    LAYER M2 ;
      RECT 220 0 2590 500 ;
    LAYER M2 ;
      RECT 1595 230 1775 1150 ;
    LAYER M2 ;
      RECT 1035 230 1215 1150 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M2 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 2040 2590 2540 ;
    LAYER M3 ;
      RECT 955 1665 1855 2175 ;
    LAYER M3 ;
      RECT 955 1485 1855 1665 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M4 ;
      RECT 490 1150 2485 1390 ;
    LAYER M4 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M4 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M4 ;
      RECT 755 1150 935 1390 ;
    LAYER M4 ;
      RECT 220 1150 500 1390 ;
    LAYER M4 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 1080 1150 1170 1390 ;
    LAYER M1 ;
      RECT 1360 1150 1450 1390 ;
    LAYER M1 ;
      RECT 1640 1150 1730 1390 ;
    LAYER M1 ;
      RECT 1920 1150 2010 1390 ;
    LAYER M1 ;
      RECT 800 1150 890 1390 ;
    LAYER M1 ;
      RECT 955 1485 1855 1665 ;
    LAYER M1 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M1 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M1 ;
      RECT 755 1150 935 1390 ;
    LAYER M1 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M1 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M1 ;
      RECT 220 710 500 1170 ;
    LAYER M1 ;
      RECT 2310 710 2590 1170 ;
    LAYER M1 ;
      RECT 220 1370 500 1830 ;
    LAYER M1 ;
      RECT 2310 1370 2590 1830 ;
    LAYER M1 ;
      RECT 220 500 2590 710 ;
    LAYER M1 ;
      RECT 220 1830 2590 2040 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 955 1530 1855 1620 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER Poly ;
      RECT 955 1470 1855 1680 ;
    LAYER Poly ;
      RECT 955 1030 1015 1170 ;
    LAYER Poly ;
      RECT 955 1370 1015 1470 ;
    LAYER Poly ;
      RECT 1235 1030 1295 1170 ;
    LAYER Poly ;
      RECT 1235 1370 1295 1470 ;
    LAYER Poly ;
      RECT 1515 1030 1575 1170 ;
    LAYER Poly ;
      RECT 1515 1370 1575 1470 ;
    LAYER Poly ;
      RECT 1795 1030 1855 1170 ;
    LAYER Poly ;
      RECT 1795 1370 1855 1470 ;
    LAYER Poly ;
      RECT 1795 1170 1855 1370 ;
    LAYER Poly ;
      RECT 1515 1170 1575 1370 ;
    LAYER Poly ;
      RECT 1235 1170 1295 1370 ;
    LAYER Poly ;
      RECT 955 1170 1015 1370 ;
  END
END bias_mos1

MACRO drain_ind1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN drain_ind1 0 0 ;
  SIZE 110000 BY 42000 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 2000 22000 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 108000 20000 110000 22000 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 110000 22000 ;
    LAYER M1 ;
      RECT 2000 0 108000 42000 ;
  END
END drain_ind1

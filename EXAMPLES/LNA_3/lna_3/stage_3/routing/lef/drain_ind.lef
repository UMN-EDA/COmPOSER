MACRO drain_ind
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN drain_ind 0 0 ;
  SIZE 85000 BY 43000 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 3000 23000 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 82000 20000 85000 23000 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 85000 23000 ;
    LAYER M1 ;
      RECT 3000 0 82000 43000 ;
  END
END drain_ind

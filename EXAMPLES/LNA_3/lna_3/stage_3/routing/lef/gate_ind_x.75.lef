MACRO gate_ind_x.75
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gate_ind_x.75 0 0 ;
  SIZE 120678 BY 122678 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 115178 63460 120678 68960 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 53718 0 59218 5500 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 102178 61210 112178 71210 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 74428 63460 95928 68960 ;
    LAYER M8 ;
      RECT 0 9742 112936 122678 ;
    LAYER M9 ;
      RECT 90428 63460 120678 68960 ;
    LAYER M9 ;
      RECT 25008 32750 87928 99670 ;
    LAYER M9 ;
      RECT 53718 0 59218 38250 ;
    LAYER M9 ;
      RECT 0 9742 112936 122678 ;
    LAYER M1 ;
      RECT 0 9742 112936 122678 ;
    LAYER M2 ;
      RECT 0 9742 112936 122678 ;
    LAYER M3 ;
      RECT 0 9742 112936 122678 ;
    LAYER M4 ;
      RECT 0 9742 112936 122678 ;
    LAYER M5 ;
      RECT 0 9742 112936 122678 ;
    LAYER M6 ;
      RECT 0 9742 112936 122678 ;
    LAYER M7 ;
      RECT 0 9742 112936 122678 ;
  END
END gate_ind_x.75

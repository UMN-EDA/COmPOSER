MACRO xwg1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xwg1 0 0 ;
  SIZE 65000 BY 36250 ;
  PIN GND1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 27765 1000 37235 9470 ;
    END
  END GND1
  PIN GND2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 27765 26780 37235 35250 ;
    END
  END GND2
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 2335 13390 11805 22860 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 53195 13390 62665 22860 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 2335 13390 62665 22860 ;
    LAYER M9 ;
      RECT 2335 26780 62665 35250 ;
    LAYER M9 ;
      RECT 2335 1000 62665 9470 ;
    LAYER M9 ;
      RECT 0 33350 65000 36250 ;
    LAYER M9 ;
      RECT 0 0 65000 2900 ;
    LAYER M8 ;
      RECT 0 33350 65000 36250 ;
    LAYER M8 ;
      RECT 0 0 65000 2900 ;
    LAYER M8 ;
      RECT 0 0 2000 36250 ;
    LAYER M8 ;
      RECT 3000 0 5000 36250 ;
    LAYER M8 ;
      RECT 6000 0 8000 36250 ;
    LAYER M8 ;
      RECT 9000 0 11000 36250 ;
    LAYER M8 ;
      RECT 12000 0 14000 36250 ;
    LAYER M8 ;
      RECT 15000 0 17000 36250 ;
    LAYER M8 ;
      RECT 18000 0 20000 36250 ;
    LAYER M8 ;
      RECT 21000 0 23000 36250 ;
    LAYER M8 ;
      RECT 24000 0 26000 36250 ;
    LAYER M8 ;
      RECT 27000 0 29000 36250 ;
    LAYER M8 ;
      RECT 30000 0 32000 36250 ;
    LAYER M8 ;
      RECT 33000 0 35000 36250 ;
    LAYER M8 ;
      RECT 36000 0 38000 36250 ;
    LAYER M8 ;
      RECT 39000 0 41000 36250 ;
    LAYER M8 ;
      RECT 42000 0 44000 36250 ;
    LAYER M8 ;
      RECT 45000 0 47000 36250 ;
    LAYER M8 ;
      RECT 48000 0 50000 36250 ;
    LAYER M8 ;
      RECT 51000 0 53000 36250 ;
    LAYER M8 ;
      RECT 54000 0 56000 36250 ;
    LAYER M8 ;
      RECT 57000 0 59000 36250 ;
    LAYER M8 ;
      RECT 60000 0 62000 36250 ;
    LAYER M8 ;
      RECT 63000 0 65000 36250 ;
  END
END xwg1

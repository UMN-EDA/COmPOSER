MACRO bias
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END bias
MACRO bias_mos
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias_mos 0 0 ;
  SIZE 2810 BY 2540 ;
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 220 2140 2590 2540 ;
    END
  END G
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M2 ;
        RECT 220 0 2590 450 ;
    END
  END D
  PIN BS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 2310 1150 2590 1390 ;
    END
  END BS
  OBS
    LAYER M2 ;
      RECT 220 0 2590 500 ;
    LAYER M2 ;
      RECT 1595 230 1775 1150 ;
    LAYER M2 ;
      RECT 1035 230 1215 1150 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 955 1485 1855 1665 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M2 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M2 ;
      RECT 755 1125 935 1415 ;
    LAYER M2 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M2 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M2 ;
      RECT 220 1150 500 1390 ;
    LAYER M2 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 2040 2590 2540 ;
    LAYER M3 ;
      RECT 955 1665 1855 2175 ;
    LAYER M3 ;
      RECT 955 1485 1855 1665 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 1875 1125 2055 1415 ;
    LAYER M3 ;
      RECT 1315 1125 1495 1415 ;
    LAYER M3 ;
      RECT 755 1125 935 1415 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M3 ;
      RECT 220 1150 500 1390 ;
    LAYER M3 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M4 ;
      RECT 490 1150 2485 1390 ;
    LAYER M4 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M4 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M4 ;
      RECT 755 1150 935 1390 ;
    LAYER M4 ;
      RECT 220 1150 500 1390 ;
    LAYER M4 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 1080 1150 1170 1390 ;
    LAYER M1 ;
      RECT 1360 1150 1450 1390 ;
    LAYER M1 ;
      RECT 1640 1150 1730 1390 ;
    LAYER M1 ;
      RECT 1920 1150 2010 1390 ;
    LAYER M1 ;
      RECT 800 1150 890 1390 ;
    LAYER M1 ;
      RECT 955 1485 1855 1665 ;
    LAYER M1 ;
      RECT 1875 1150 2055 1390 ;
    LAYER M1 ;
      RECT 1315 1150 1495 1390 ;
    LAYER M1 ;
      RECT 755 1150 935 1390 ;
    LAYER M1 ;
      RECT 1595 1150 1775 1390 ;
    LAYER M1 ;
      RECT 1035 1150 1215 1390 ;
    LAYER M1 ;
      RECT 220 710 500 1170 ;
    LAYER M1 ;
      RECT 2310 710 2590 1170 ;
    LAYER M1 ;
      RECT 220 1370 500 1830 ;
    LAYER M1 ;
      RECT 2310 1370 2590 1830 ;
    LAYER M1 ;
      RECT 220 500 2590 710 ;
    LAYER M1 ;
      RECT 220 1830 2590 2040 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 955 1530 1855 1620 ;
    LAYER M1 ;
      RECT 2310 1150 2590 1390 ;
    LAYER M1 ;
      RECT 220 1150 500 1390 ;
    LAYER Poly ;
      RECT 955 1470 1855 1680 ;
    LAYER Poly ;
      RECT 955 1030 1015 1170 ;
    LAYER Poly ;
      RECT 955 1370 1015 1470 ;
    LAYER Poly ;
      RECT 1235 1030 1295 1170 ;
    LAYER Poly ;
      RECT 1235 1370 1295 1470 ;
    LAYER Poly ;
      RECT 1515 1030 1575 1170 ;
    LAYER Poly ;
      RECT 1515 1370 1575 1470 ;
    LAYER Poly ;
      RECT 1795 1030 1855 1170 ;
    LAYER Poly ;
      RECT 1795 1370 1855 1470 ;
    LAYER Poly ;
      RECT 1795 1170 1855 1370 ;
    LAYER Poly ;
      RECT 1515 1170 1575 1370 ;
    LAYER Poly ;
      RECT 1235 1170 1295 1370 ;
    LAYER Poly ;
      RECT 955 1170 1015 1370 ;
  END
END bias_mos
MACRO cas_mos
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN cas_mos 0 0 ;
  SIZE 6625 BY 8530 ;
  PIN SS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M7 ;
        RECT 0 4850 300 5890 ;
    END
  END SS
  PIN GG
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1365 7530 5625 8530 ;
    END
  END GG
  PIN DD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1165 0 5825 1000 ;
    END
  END DD
  PIN G2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 6125 2880 6625 4480 ;
    END
  END G2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 700 4368 910 4578 ;
    END
  END GND
  OBS
    LAYER M6 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 1365 6530 5625 6890 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 1165 1470 5825 2000 ;
    LAYER M1 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M1 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M1 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M1 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M1 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M1 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M1 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M1 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M1 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M1 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M1 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M1 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M1 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M1 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M1 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M1 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M1 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M1 ;
      RECT 1365 5990 5625 6170 ;
    LAYER M1 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M1 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M1 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M1 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M1 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M1 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M1 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M1 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M1 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M1 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M1 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M1 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M1 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M1 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M1 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M1 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M1 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M1 ;
      RECT 1365 4300 5625 4480 ;
    LAYER M1 ;
      RECT 1365 2880 5625 3060 ;
    LAYER M1 ;
      RECT 700 2510 6290 6540 ;
    LAYER M2 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M2 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M2 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M2 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M2 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M2 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M2 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M2 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M2 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M2 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M2 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M2 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M2 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M2 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M2 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M2 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M2 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M2 ;
      RECT 1365 5990 5625 6170 ;
    LAYER M2 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M2 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M2 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M2 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M2 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M2 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M2 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M2 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M2 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M2 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M2 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M2 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M2 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M2 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M2 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M2 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M2 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M2 ;
      RECT 1365 4300 5625 4480 ;
    LAYER M2 ;
      RECT 1365 2880 5625 3060 ;
    LAYER M3 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M3 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M3 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M3 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M3 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M3 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M3 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M3 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M3 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M3 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M3 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M3 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M3 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M3 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M3 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M3 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M3 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M3 ;
      RECT 1365 5990 5625 6170 ;
    LAYER M3 ;
      RECT 1365 6170 5625 6350 ;
    LAYER M3 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M3 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M3 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M3 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M3 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M3 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M3 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M3 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M3 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M3 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M3 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M3 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M3 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M3 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M3 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M3 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M3 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M3 ;
      RECT 1365 4300 5625 4480 ;
    LAYER M3 ;
      RECT 5625 4300 6125 4480 ;
    LAYER M3 ;
      RECT 1365 2880 5625 3060 ;
    LAYER M3 ;
      RECT 5625 2880 6125 3060 ;
    LAYER M3 ;
      RECT 6125 2880 6625 4480 ;
    LAYER M4 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M4 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 1365 6170 5625 6530 ;
    LAYER M4 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M4 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M4 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M4 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M4 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M4 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M4 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M4 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M4 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M4 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M4 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M4 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M4 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M4 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M4 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M4 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M4 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M5 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M5 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M5 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M5 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M5 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M5 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M5 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M5 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M5 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M5 ;
      RECT 1365 6350 5625 6710 ;
    LAYER M5 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M5 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M5 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M5 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M5 ;
      RECT 1165 1470 5825 2000 ;
    LAYER Poly ;
      RECT 1365 4730 1425 5970 ;
    LAYER Poly ;
      RECT 1645 4730 1705 5970 ;
    LAYER Poly ;
      RECT 1925 4730 1985 5970 ;
    LAYER Poly ;
      RECT 2205 4730 2265 5970 ;
    LAYER Poly ;
      RECT 2485 4730 2545 5970 ;
    LAYER Poly ;
      RECT 2765 4730 2825 5970 ;
    LAYER Poly ;
      RECT 3045 4730 3105 5970 ;
    LAYER Poly ;
      RECT 3325 4730 3385 5970 ;
    LAYER Poly ;
      RECT 3605 4730 3665 5970 ;
    LAYER Poly ;
      RECT 3885 4730 3945 5970 ;
    LAYER Poly ;
      RECT 4165 4730 4225 5970 ;
    LAYER Poly ;
      RECT 4445 4730 4505 5970 ;
    LAYER Poly ;
      RECT 4725 4730 4785 5970 ;
    LAYER Poly ;
      RECT 5005 4730 5065 5970 ;
    LAYER Poly ;
      RECT 5285 4730 5345 5970 ;
    LAYER Poly ;
      RECT 5565 4730 5625 5970 ;
    LAYER Poly ;
      RECT 1365 5970 5625 6180 ;
    LAYER Poly ;
      RECT 1365 3080 1425 4280 ;
    LAYER Poly ;
      RECT 1645 3080 1705 4280 ;
    LAYER Poly ;
      RECT 1925 3080 1985 4280 ;
    LAYER Poly ;
      RECT 2205 3080 2265 4280 ;
    LAYER Poly ;
      RECT 2485 3080 2545 4280 ;
    LAYER Poly ;
      RECT 2765 3080 2825 4280 ;
    LAYER Poly ;
      RECT 3045 3080 3105 4280 ;
    LAYER Poly ;
      RECT 3325 3080 3385 4280 ;
    LAYER Poly ;
      RECT 3605 3080 3665 4280 ;
    LAYER Poly ;
      RECT 3885 3080 3945 4280 ;
    LAYER Poly ;
      RECT 4165 3080 4225 4280 ;
    LAYER Poly ;
      RECT 4445 3080 4505 4280 ;
    LAYER Poly ;
      RECT 4725 3080 4785 4280 ;
    LAYER Poly ;
      RECT 5005 3080 5065 4280 ;
    LAYER Poly ;
      RECT 5285 3080 5345 4280 ;
    LAYER Poly ;
      RECT 5565 3080 5625 4280 ;
    LAYER Poly ;
      RECT 1365 4280 5625 4490 ;
    LAYER Poly ;
      RECT 1365 2870 5625 3080 ;
    LAYER M7 ;
      RECT 0 4850 5825 5890 ;
    LAYER M7 ;
      RECT 1365 6710 5625 7410 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 1165 1470 5825 2000 ;
    LAYER M8 ;
      RECT 1365 6710 5625 7750 ;
    LAYER M8 ;
      RECT 1165 760 5825 2000 ;
    LAYER M9 ;
      RECT 1365 6530 5625 8530 ;
    LAYER M9 ;
      RECT 1165 0 5825 2000 ;
  END
END cas_mos
MACRO drain_ind
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN drain_ind 0 0 ;
  SIZE 85000 BY 43000 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 3000 23000 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 82000 20000 85000 23000 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 85000 23000 ;
    LAYER M1 ;
      RECT 3000 0 82000 43000 ;
  END
END drain_ind
MACRO gate_ind_x.75
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gate_ind_x.75 0 0 ;
  SIZE 120678 BY 122678 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 115178 63460 120678 68960 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 53718 0 59218 5500 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 102178 61210 112178 71210 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 74428 63460 95928 68960 ;
    LAYER M8 ;
      RECT 0 9742 112936 122678 ;
    LAYER M9 ;
      RECT 90428 63460 120678 68960 ;
    LAYER M9 ;
      RECT 25008 32750 87928 99670 ;
    LAYER M9 ;
      RECT 53718 0 59218 38250 ;
    LAYER M9 ;
      RECT 0 9742 112936 122678 ;
    LAYER M1 ;
      RECT 0 9742 112936 122678 ;
    LAYER M2 ;
      RECT 0 9742 112936 122678 ;
    LAYER M3 ;
      RECT 0 9742 112936 122678 ;
    LAYER M4 ;
      RECT 0 9742 112936 122678 ;
    LAYER M5 ;
      RECT 0 9742 112936 122678 ;
    LAYER M6 ;
      RECT 0 9742 112936 122678 ;
    LAYER M7 ;
      RECT 0 9742 112936 122678 ;
  END
END gate_ind_x.75
MACRO gnd0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gnd0 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END gnd0
MACRO gnd1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gnd1 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END gnd1
MACRO gnd2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gnd2 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END gnd2
MACRO input
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN input 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END input
MACRO source_ind
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN source_ind 0 0 ;
  SIZE 95000 BY 49000 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 9000 29000 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 86000 20000 95000 29000 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 95000 29000 ;
    LAYER M1 ;
      RECT 9000 0 86000 49000 ;
  END
END source_ind
MACRO vdd
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN vdd 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 14750 0 37260 17680 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END vdd
MACRO xR0_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR0_2 0 0 ;
  SIZE 25540 BY 7840 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 7620 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 25220 220 25310 7620 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 25340 7620 ;
    LAYER RPO ;
      RECT 540 0 25000 7840 ;
    LAYER M1 ;
      RECT 230 235 320 7605 ;
    LAYER M1 ;
      RECT 25220 235 25310 7605 ;
    LAYER RH ;
      RECT 0 20 25540 7820 ;
  END
END xR0_2
MACRO xR1_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR1_2 0 0 ;
  SIZE 16790 BY 4400 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4180 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 16470 220 16560 4180 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 16590 4180 ;
    LAYER RPO ;
      RECT 540 0 16250 4400 ;
    LAYER M1 ;
      RECT 230 235 320 4165 ;
    LAYER M1 ;
      RECT 16470 235 16560 4165 ;
    LAYER RH ;
      RECT 0 20 16790 4380 ;
  END
END xR1_2
MACRO xR2_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR2_0 0 0 ;
  SIZE 4070 BY 4960 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4740 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 3750 220 3840 4740 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 3870 4740 ;
    LAYER RPO ;
      RECT 540 0 3530 4960 ;
    LAYER M1 ;
      RECT 230 235 320 4725 ;
    LAYER M1 ;
      RECT 3750 235 3840 4725 ;
    LAYER RH ;
      RECT 0 20 4070 4940 ;
  END
END xR2_0
MACRO xR3_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR3_2 0 0 ;
  SIZE 16790 BY 4400 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4180 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 16470 220 16560 4180 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 16590 4180 ;
    LAYER RPO ;
      RECT 540 0 16250 4400 ;
    LAYER M1 ;
      RECT 230 235 320 4165 ;
    LAYER M1 ;
      RECT 16470 235 16560 4165 ;
    LAYER RH ;
      RECT 0 20 16790 4380 ;
  END
END xR3_2
MACRO xc1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc1_1 0 0 ;
  SIZE 8170 BY 9610 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 9510 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 6890 4075 8170 5535 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 8050 6490 9510 ;
    LAYER M8 ;
      RECT 0 100 6490 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 8050 ;
    LAYER M8 ;
      RECT 1680 4075 8170 5535 ;
    LAYER M8 ;
      RECT 1820 2540 3280 7070 ;
    LAYER M8 ;
      RECT 4890 2540 6350 7070 ;
  END
END xc1_1
MACRO xc2_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc2_1 0 0 ;
  SIZE 26320 BY 21320 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 9978 20890 16342 21320 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 9978 0 16342 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 9480 1660 11840 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 24660 1760 26320 19560 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 12680 23820 21320 ;
    LAYER M8 ;
      RECT 2500 0 23820 8640 ;
    LAYER M8 ;
      RECT 23820 19660 26320 21320 ;
    LAYER M8 ;
      RECT 23820 0 26320 1660 ;
    LAYER M8 ;
      RECT 24660 0 26320 21320 ;
    LAYER M8 ;
      RECT 0 9480 23820 11840 ;
    LAYER M8 ;
      RECT 5000 11840 6740 18820 ;
    LAYER M8 ;
      RECT 5000 11840 6740 18820 ;
    LAYER M8 ;
      RECT 5000 2500 6740 9480 ;
    LAYER M8 ;
      RECT 7916 11840 9656 18820 ;
    LAYER M8 ;
      RECT 7916 11840 9656 18820 ;
    LAYER M8 ;
      RECT 7916 2500 9656 9480 ;
    LAYER M8 ;
      RECT 10832 11840 12572 18820 ;
    LAYER M8 ;
      RECT 10832 11840 12572 18820 ;
    LAYER M8 ;
      RECT 10832 2500 12572 9480 ;
    LAYER M8 ;
      RECT 13748 11840 15488 18820 ;
    LAYER M8 ;
      RECT 13748 11840 15488 18820 ;
    LAYER M8 ;
      RECT 13748 2500 15488 9480 ;
    LAYER M8 ;
      RECT 16664 11840 18404 18820 ;
    LAYER M8 ;
      RECT 16664 11840 18404 18820 ;
    LAYER M8 ;
      RECT 16664 2500 18404 9480 ;
    LAYER M8 ;
      RECT 19580 11840 21320 18820 ;
    LAYER M8 ;
      RECT 19580 11840 21320 18820 ;
    LAYER M8 ;
      RECT 19580 2500 21320 9480 ;
    LAYER M5 ;
      RECT 12560 0 13760 21320 ;
    LAYER M5 ;
      RECT 2500 10060 23820 11260 ;
    LAYER M5 ;
      RECT 14360 12460 15560 21320 ;
    LAYER M5 ;
      RECT 14360 11860 23820 13060 ;
    LAYER M5 ;
      RECT 16160 14260 17360 21320 ;
    LAYER M5 ;
      RECT 16160 13660 23820 14860 ;
    LAYER M5 ;
      RECT 17960 16060 19160 21320 ;
    LAYER M5 ;
      RECT 17960 15460 23820 16660 ;
    LAYER M5 ;
      RECT 19760 17860 20960 21320 ;
    LAYER M5 ;
      RECT 19760 17260 23820 18460 ;
    LAYER M5 ;
      RECT 21560 19660 22760 21320 ;
    LAYER M5 ;
      RECT 21560 19060 23820 20260 ;
    LAYER M5 ;
      RECT 23360 20860 23820 21320 ;
    LAYER M5 ;
      RECT 10760 12460 11960 21320 ;
    LAYER M5 ;
      RECT 2500 11860 11960 13060 ;
    LAYER M5 ;
      RECT 8960 14260 10160 21320 ;
    LAYER M5 ;
      RECT 2500 13660 10160 14860 ;
    LAYER M5 ;
      RECT 7160 16060 8360 21320 ;
    LAYER M5 ;
      RECT 2500 15460 8360 16660 ;
    LAYER M5 ;
      RECT 5360 17860 6560 21320 ;
    LAYER M5 ;
      RECT 2500 17260 6560 18460 ;
    LAYER M5 ;
      RECT 3560 19660 4760 21320 ;
    LAYER M5 ;
      RECT 2500 19060 4760 20260 ;
    LAYER M5 ;
      RECT 2500 20860 2960 21320 ;
    LAYER M5 ;
      RECT 10760 0 11960 8860 ;
    LAYER M5 ;
      RECT 2500 8260 11960 9460 ;
    LAYER M5 ;
      RECT 8960 0 10160 7060 ;
    LAYER M5 ;
      RECT 2500 6460 10160 7660 ;
    LAYER M5 ;
      RECT 7160 0 8360 5260 ;
    LAYER M5 ;
      RECT 2500 4660 8360 5860 ;
    LAYER M5 ;
      RECT 5360 0 6560 3460 ;
    LAYER M5 ;
      RECT 2500 2860 6560 4060 ;
    LAYER M5 ;
      RECT 3560 0 4760 1660 ;
    LAYER M5 ;
      RECT 2500 1060 4760 2260 ;
    LAYER M5 ;
      RECT 2500 0 2960 460 ;
    LAYER M5 ;
      RECT 14360 0 15560 8860 ;
    LAYER M5 ;
      RECT 14360 8260 23820 9460 ;
    LAYER M5 ;
      RECT 16160 0 17360 7060 ;
    LAYER M5 ;
      RECT 16160 6460 23820 7660 ;
    LAYER M5 ;
      RECT 17960 0 19160 5260 ;
    LAYER M5 ;
      RECT 17960 4660 23820 5860 ;
    LAYER M5 ;
      RECT 19760 0 20960 3460 ;
    LAYER M5 ;
      RECT 19760 2860 23820 4060 ;
    LAYER M5 ;
      RECT 21560 0 22760 1660 ;
    LAYER M5 ;
      RECT 21560 1060 23820 2260 ;
    LAYER M5 ;
      RECT 23360 0 23820 460 ;
    LAYER M5 ;
      RECT 2500 20890 23820 21320 ;
    LAYER M5 ;
      RECT 2500 0 23820 430 ;
    LAYER M6 ;
      RECT 13460 11560 14660 21320 ;
    LAYER M6 ;
      RECT 13460 10960 23820 12160 ;
    LAYER M6 ;
      RECT 15260 13360 16460 21320 ;
    LAYER M6 ;
      RECT 15260 12760 23820 13960 ;
    LAYER M6 ;
      RECT 17060 15160 18260 21320 ;
    LAYER M6 ;
      RECT 17060 14560 23820 15760 ;
    LAYER M6 ;
      RECT 18860 16960 20060 21320 ;
    LAYER M6 ;
      RECT 18860 16360 23820 17560 ;
    LAYER M6 ;
      RECT 20660 18760 21860 21320 ;
    LAYER M6 ;
      RECT 20660 18160 23820 19360 ;
    LAYER M6 ;
      RECT 22460 20560 23660 21320 ;
    LAYER M6 ;
      RECT 22460 19960 23820 21160 ;
    LAYER M6 ;
      RECT 11660 11560 12860 21320 ;
    LAYER M6 ;
      RECT 2500 10960 12860 12160 ;
    LAYER M6 ;
      RECT 9860 13360 11060 21320 ;
    LAYER M6 ;
      RECT 2500 12760 11060 13960 ;
    LAYER M6 ;
      RECT 8060 15160 9260 21320 ;
    LAYER M6 ;
      RECT 2500 14560 9260 15760 ;
    LAYER M6 ;
      RECT 6260 16960 7460 21320 ;
    LAYER M6 ;
      RECT 2500 16360 7460 17560 ;
    LAYER M6 ;
      RECT 4460 18760 5660 21320 ;
    LAYER M6 ;
      RECT 2500 18160 5660 19360 ;
    LAYER M6 ;
      RECT 2660 20560 3860 21320 ;
    LAYER M6 ;
      RECT 2500 19960 3860 21160 ;
    LAYER M6 ;
      RECT 11660 0 12860 9760 ;
    LAYER M6 ;
      RECT 2500 9160 12860 10360 ;
    LAYER M6 ;
      RECT 9860 0 11060 7960 ;
    LAYER M6 ;
      RECT 2500 7360 11060 8560 ;
    LAYER M6 ;
      RECT 8060 0 9260 6160 ;
    LAYER M6 ;
      RECT 2500 5560 9260 6760 ;
    LAYER M6 ;
      RECT 6260 0 7460 4360 ;
    LAYER M6 ;
      RECT 2500 3760 7460 4960 ;
    LAYER M6 ;
      RECT 4460 0 5660 2560 ;
    LAYER M6 ;
      RECT 2500 1960 5660 3160 ;
    LAYER M6 ;
      RECT 2660 0 3860 760 ;
    LAYER M6 ;
      RECT 2500 160 3860 1360 ;
    LAYER M6 ;
      RECT 13460 0 14660 9760 ;
    LAYER M6 ;
      RECT 13460 9160 23820 10360 ;
    LAYER M6 ;
      RECT 15260 0 16460 7960 ;
    LAYER M6 ;
      RECT 15260 7360 23820 8560 ;
    LAYER M6 ;
      RECT 17060 0 18260 6160 ;
    LAYER M6 ;
      RECT 17060 5560 23820 6760 ;
    LAYER M6 ;
      RECT 18860 0 20060 4360 ;
    LAYER M6 ;
      RECT 18860 3760 23820 4960 ;
    LAYER M6 ;
      RECT 20660 0 21860 2560 ;
    LAYER M6 ;
      RECT 20660 1960 23820 3160 ;
    LAYER M6 ;
      RECT 22460 0 23660 760 ;
    LAYER M6 ;
      RECT 22460 160 23820 1360 ;
    LAYER M6 ;
      RECT 2500 20890 23820 21320 ;
    LAYER M6 ;
      RECT 2500 0 23820 430 ;
  END
END xc2_1
MACRO xc3_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc3_1 0 0 ;
  SIZE 20660 BY 15660 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 15230 12568 15660 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 0 12568 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 6650 1660 9010 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 19000 1760 20660 13900 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 9850 18160 15660 ;
    LAYER M8 ;
      RECT 2500 0 18160 5810 ;
    LAYER M8 ;
      RECT 18160 14000 20660 15660 ;
    LAYER M8 ;
      RECT 18160 0 20660 1660 ;
    LAYER M8 ;
      RECT 19000 0 20660 15660 ;
    LAYER M8 ;
      RECT 0 6650 18160 9010 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 2500 6740 6650 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 2500 9713 6650 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 2500 12687 6650 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 2500 15660 6650 ;
    LAYER M5 ;
      RECT 9730 0 10930 15660 ;
    LAYER M5 ;
      RECT 2500 7230 18160 8430 ;
    LAYER M5 ;
      RECT 11530 9630 12730 15660 ;
    LAYER M5 ;
      RECT 11530 9030 18160 10230 ;
    LAYER M5 ;
      RECT 13330 11430 14530 15660 ;
    LAYER M5 ;
      RECT 13330 10830 18160 12030 ;
    LAYER M5 ;
      RECT 15130 13230 16330 15660 ;
    LAYER M5 ;
      RECT 15130 12630 18160 13830 ;
    LAYER M5 ;
      RECT 16930 15030 18130 15660 ;
    LAYER M5 ;
      RECT 16930 14430 18160 15630 ;
    LAYER M5 ;
      RECT 7930 9630 9130 15660 ;
    LAYER M5 ;
      RECT 2500 9030 9130 10230 ;
    LAYER M5 ;
      RECT 6130 11430 7330 15660 ;
    LAYER M5 ;
      RECT 2500 10830 7330 12030 ;
    LAYER M5 ;
      RECT 4330 13230 5530 15660 ;
    LAYER M5 ;
      RECT 2500 12630 5530 13830 ;
    LAYER M5 ;
      RECT 2530 15030 3730 15660 ;
    LAYER M5 ;
      RECT 2500 14430 3730 15630 ;
    LAYER M5 ;
      RECT 7930 0 9130 6030 ;
    LAYER M5 ;
      RECT 2500 5430 9130 6630 ;
    LAYER M5 ;
      RECT 6130 0 7330 4230 ;
    LAYER M5 ;
      RECT 2500 3630 7330 4830 ;
    LAYER M5 ;
      RECT 4330 0 5530 2430 ;
    LAYER M5 ;
      RECT 2500 1830 5530 3030 ;
    LAYER M5 ;
      RECT 2530 0 3730 630 ;
    LAYER M5 ;
      RECT 2500 30 3730 1230 ;
    LAYER M5 ;
      RECT 11530 0 12730 6030 ;
    LAYER M5 ;
      RECT 11530 5430 18160 6630 ;
    LAYER M5 ;
      RECT 13330 0 14530 4230 ;
    LAYER M5 ;
      RECT 13330 3630 18160 4830 ;
    LAYER M5 ;
      RECT 15130 0 16330 2430 ;
    LAYER M5 ;
      RECT 15130 1830 18160 3030 ;
    LAYER M5 ;
      RECT 16930 0 18130 630 ;
    LAYER M5 ;
      RECT 16930 30 18160 1230 ;
    LAYER M5 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M5 ;
      RECT 2500 0 18160 430 ;
    LAYER M6 ;
      RECT 10630 8730 11830 15660 ;
    LAYER M6 ;
      RECT 10630 8130 18160 9330 ;
    LAYER M6 ;
      RECT 12430 10530 13630 15660 ;
    LAYER M6 ;
      RECT 12430 9930 18160 11130 ;
    LAYER M6 ;
      RECT 14230 12330 15430 15660 ;
    LAYER M6 ;
      RECT 14230 11730 18160 12930 ;
    LAYER M6 ;
      RECT 16030 14130 17230 15660 ;
    LAYER M6 ;
      RECT 16030 13530 18160 14730 ;
    LAYER M6 ;
      RECT 8830 8730 10030 15660 ;
    LAYER M6 ;
      RECT 2500 8130 10030 9330 ;
    LAYER M6 ;
      RECT 7030 10530 8230 15660 ;
    LAYER M6 ;
      RECT 2500 9930 8230 11130 ;
    LAYER M6 ;
      RECT 5230 12330 6430 15660 ;
    LAYER M6 ;
      RECT 2500 11730 6430 12930 ;
    LAYER M6 ;
      RECT 3430 14130 4630 15660 ;
    LAYER M6 ;
      RECT 2500 13530 4630 14730 ;
    LAYER M6 ;
      RECT 8830 0 10030 6930 ;
    LAYER M6 ;
      RECT 2500 6330 10030 7530 ;
    LAYER M6 ;
      RECT 7030 0 8230 5130 ;
    LAYER M6 ;
      RECT 2500 4530 8230 5730 ;
    LAYER M6 ;
      RECT 5230 0 6430 3330 ;
    LAYER M6 ;
      RECT 2500 2730 6430 3930 ;
    LAYER M6 ;
      RECT 3430 0 4630 1530 ;
    LAYER M6 ;
      RECT 2500 930 4630 2130 ;
    LAYER M6 ;
      RECT 10630 0 11830 6930 ;
    LAYER M6 ;
      RECT 10630 6330 18160 7530 ;
    LAYER M6 ;
      RECT 12430 0 13630 5130 ;
    LAYER M6 ;
      RECT 12430 4530 18160 5730 ;
    LAYER M6 ;
      RECT 14230 0 15430 3330 ;
    LAYER M6 ;
      RECT 14230 2730 18160 3930 ;
    LAYER M6 ;
      RECT 16030 0 17230 1530 ;
    LAYER M6 ;
      RECT 16030 930 18160 2130 ;
    LAYER M6 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M6 ;
      RECT 2500 0 18160 430 ;
  END
END xc3_1
MACRO xwg1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xwg1 0 0 ;
  SIZE 65000 BY 36250 ;
  PIN GND1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 27765 1000 37235 9470 ;
    END
  END GND1
  PIN GND2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 27765 26780 37235 35250 ;
    END
  END GND2
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 2335 13390 11805 22860 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 53195 13390 62665 22860 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 2335 13390 62665 22860 ;
    LAYER M9 ;
      RECT 2335 26780 62665 35250 ;
    LAYER M9 ;
      RECT 2335 1000 62665 9470 ;
    LAYER M9 ;
      RECT 0 33350 65000 36250 ;
    LAYER M9 ;
      RECT 0 0 65000 2900 ;
    LAYER M8 ;
      RECT 0 33350 65000 36250 ;
    LAYER M8 ;
      RECT 0 0 65000 2900 ;
    LAYER M8 ;
      RECT 0 0 2000 36250 ;
    LAYER M8 ;
      RECT 3000 0 5000 36250 ;
    LAYER M8 ;
      RECT 6000 0 8000 36250 ;
    LAYER M8 ;
      RECT 9000 0 11000 36250 ;
    LAYER M8 ;
      RECT 12000 0 14000 36250 ;
    LAYER M8 ;
      RECT 15000 0 17000 36250 ;
    LAYER M8 ;
      RECT 18000 0 20000 36250 ;
    LAYER M8 ;
      RECT 21000 0 23000 36250 ;
    LAYER M8 ;
      RECT 24000 0 26000 36250 ;
    LAYER M8 ;
      RECT 27000 0 29000 36250 ;
    LAYER M8 ;
      RECT 30000 0 32000 36250 ;
    LAYER M8 ;
      RECT 33000 0 35000 36250 ;
    LAYER M8 ;
      RECT 36000 0 38000 36250 ;
    LAYER M8 ;
      RECT 39000 0 41000 36250 ;
    LAYER M8 ;
      RECT 42000 0 44000 36250 ;
    LAYER M8 ;
      RECT 45000 0 47000 36250 ;
    LAYER M8 ;
      RECT 48000 0 50000 36250 ;
    LAYER M8 ;
      RECT 51000 0 53000 36250 ;
    LAYER M8 ;
      RECT 54000 0 56000 36250 ;
    LAYER M8 ;
      RECT 57000 0 59000 36250 ;
    LAYER M8 ;
      RECT 60000 0 62000 36250 ;
    LAYER M8 ;
      RECT 63000 0 65000 36250 ;
  END
END xwg1

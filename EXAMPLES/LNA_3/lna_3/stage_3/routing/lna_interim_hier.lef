MACRO lna
  UNITS
    DISTANCE MICRONS 1;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN lna 0 0 ;
  SIZE 853011 BY 390824 ;
    OBS
      LAYER M1 ;
        RECT 227939 259755 228179 259845 ;
        RECT 227939 260035 228179 260125 ;
        RECT 227939 260315 228179 260405 ;
        RECT 227939 260595 228179 260685 ;
        RECT 227939 259475 228179 259565 ;
        RECT 227664 259630 227844 260530 ;
        RECT 227939 260550 228179 260730 ;
        RECT 227939 259990 228179 260170 ;
        RECT 227939 259430 228179 259610 ;
        RECT 227939 260270 228179 260450 ;
        RECT 227939 259710 228179 259890 ;
        RECT 228159 258895 228619 259175 ;
        RECT 228159 260985 228619 261265 ;
        RECT 227499 258895 227959 259175 ;
        RECT 227499 260985 227959 261265 ;
        RECT 228619 258895 228829 261265 ;
        RECT 227289 258895 227499 261265 ;
        RECT 227939 258895 228179 259175 ;
        RECT 227939 260985 228179 261265 ;
        RECT 227709 259630 227799 260530 ;
        RECT 227939 260985 228179 261265 ;
        RECT 227939 258895 228179 259175 ;
        RECT 234680 279105 234860 280145 ;
        RECT 230200 279105 230380 280145 ;
        RECT 234400 279105 234580 280145 ;
        RECT 234120 279105 234300 280145 ;
        RECT 233840 279105 234020 280145 ;
        RECT 233560 279105 233740 280145 ;
        RECT 233280 279105 233460 280145 ;
        RECT 233000 279105 233180 280145 ;
        RECT 232720 279105 232900 280145 ;
        RECT 232440 279105 232620 280145 ;
        RECT 232160 279105 232340 280145 ;
        RECT 231880 279105 232060 280145 ;
        RECT 231600 279105 231780 280145 ;
        RECT 231320 279105 231500 280145 ;
        RECT 231040 279105 231220 280145 ;
        RECT 230760 279105 230940 280145 ;
        RECT 230480 279105 230660 280145 ;
        RECT 230400 278825 234660 279005 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234400 280795 234580 281835 ;
        RECT 234120 280795 234300 281835 ;
        RECT 233840 280795 234020 281835 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233280 280795 233460 281835 ;
        RECT 233000 280795 233180 281835 ;
        RECT 232720 280795 232900 281835 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232160 280795 232340 281835 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231600 280795 231780 281835 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231040 280795 231220 281835 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230480 280795 230660 281835 ;
        RECT 230400 280515 234660 280695 ;
        RECT 230400 281935 234660 282115 ;
        RECT 229735 278455 235325 282485 ;
        RECT 144725 264915 223725 307915 ;
        RECT 176062 129597 288998 242533 ;
        RECT 254865 255125 331865 304125 ;
        RECT 237260 259685 244630 259775 ;
        RECT 237260 284675 244630 284765 ;
        RECT 226944 253510 227034 257440 ;
        RECT 243184 253510 243274 257440 ;
        RECT 244420 289440 244510 293930 ;
        RECT 240900 289440 240990 293930 ;
        RECT 230564 258905 234494 258995 ;
        RECT 230564 275145 234494 275235 ;
      LAYER M2 ;
        RECT 228829 258895 229329 261265 ;
        RECT 228179 260270 229099 260450 ;
        RECT 228179 259710 229099 259890 ;
        RECT 227664 259630 227844 260530 ;
        RECT 227664 259630 227844 260530 ;
        RECT 227914 260550 228204 260730 ;
        RECT 227914 259990 228204 260170 ;
        RECT 227914 259430 228204 259610 ;
        RECT 227914 260550 228204 260730 ;
        RECT 227914 259990 228204 260170 ;
        RECT 227914 259430 228204 259610 ;
        RECT 227939 260270 228179 260450 ;
        RECT 227939 259710 228179 259890 ;
        RECT 227939 258895 228179 259175 ;
        RECT 227939 260985 228179 261265 ;
        RECT 227939 258895 228179 259175 ;
        RECT 227939 260985 228179 261265 ;
        RECT 234680 279105 234860 280145 ;
        RECT 230200 279105 230380 280145 ;
        RECT 234400 279105 234580 280145 ;
        RECT 234120 279105 234300 280145 ;
        RECT 233840 279105 234020 280145 ;
        RECT 233560 279105 233740 280145 ;
        RECT 233280 279105 233460 280145 ;
        RECT 233000 279105 233180 280145 ;
        RECT 232720 279105 232900 280145 ;
        RECT 232440 279105 232620 280145 ;
        RECT 232160 279105 232340 280145 ;
        RECT 231880 279105 232060 280145 ;
        RECT 231600 279105 231780 280145 ;
        RECT 231320 279105 231500 280145 ;
        RECT 231040 279105 231220 280145 ;
        RECT 230760 279105 230940 280145 ;
        RECT 230480 279105 230660 280145 ;
        RECT 230400 278825 234660 279005 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234400 280795 234580 281835 ;
        RECT 234120 280795 234300 281835 ;
        RECT 233840 280795 234020 281835 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233280 280795 233460 281835 ;
        RECT 233000 280795 233180 281835 ;
        RECT 232720 280795 232900 281835 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232160 280795 232340 281835 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231600 280795 231780 281835 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231040 280795 231220 281835 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230480 280795 230660 281835 ;
        RECT 230400 280515 234660 280695 ;
        RECT 230400 281935 234660 282115 ;
        RECT 176062 129597 288998 242533 ;
      LAYER M3 ;
        RECT 226789 258895 227289 261265 ;
        RECT 227154 259630 227664 260530 ;
        RECT 227664 259630 227844 260530 ;
        RECT 227914 260550 228204 260730 ;
        RECT 227914 259990 228204 260170 ;
        RECT 227914 259430 228204 259610 ;
        RECT 227914 260550 228204 260730 ;
        RECT 227914 259990 228204 260170 ;
        RECT 227914 259430 228204 259610 ;
        RECT 227939 258895 228179 259175 ;
        RECT 227939 260985 228179 261265 ;
        RECT 227939 258895 228179 259175 ;
        RECT 227939 260985 228179 261265 ;
        RECT 234680 279105 234860 280145 ;
        RECT 230200 279105 230380 280145 ;
        RECT 234400 279105 234580 280145 ;
        RECT 234120 279105 234300 280145 ;
        RECT 233840 279105 234020 280145 ;
        RECT 233560 279105 233740 280145 ;
        RECT 233280 279105 233460 280145 ;
        RECT 233000 279105 233180 280145 ;
        RECT 232720 279105 232900 280145 ;
        RECT 232440 279105 232620 280145 ;
        RECT 232160 279105 232340 280145 ;
        RECT 231880 279105 232060 280145 ;
        RECT 231600 279105 231780 280145 ;
        RECT 231320 279105 231500 280145 ;
        RECT 231040 279105 231220 280145 ;
        RECT 230760 279105 230940 280145 ;
        RECT 230480 279105 230660 280145 ;
        RECT 230400 278825 234660 279005 ;
        RECT 230400 278645 234660 278825 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234400 280795 234580 281835 ;
        RECT 234120 280795 234300 281835 ;
        RECT 233840 280795 234020 281835 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233280 280795 233460 281835 ;
        RECT 233000 280795 233180 281835 ;
        RECT 232720 280795 232900 281835 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232160 280795 232340 281835 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231600 280795 231780 281835 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231040 280795 231220 281835 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230480 280795 230660 281835 ;
        RECT 230400 280515 234660 280695 ;
        RECT 229900 280515 230400 280695 ;
        RECT 230400 281935 234660 282115 ;
        RECT 229900 281935 230400 282115 ;
        RECT 229400 280515 229900 282115 ;
        RECT 176062 129597 288998 242533 ;
      LAYER M4 ;
        RECT 227939 259165 228179 261160 ;
        RECT 227939 260550 228179 260730 ;
        RECT 227939 259990 228179 260170 ;
        RECT 227939 259430 228179 259610 ;
        RECT 227939 258895 228179 259175 ;
        RECT 227939 260985 228179 261265 ;
        RECT 234680 279105 234860 280145 ;
        RECT 230200 279105 230380 280145 ;
        RECT 234400 280145 234580 280795 ;
        RECT 234400 280145 234580 280795 ;
        RECT 234400 280145 234580 280795 ;
        RECT 234400 280145 234580 280795 ;
        RECT 234400 279105 234580 280145 ;
        RECT 234400 280145 234580 280795 ;
        RECT 234120 279105 234300 280145 ;
        RECT 233840 280145 234020 280795 ;
        RECT 233840 280145 234020 280795 ;
        RECT 233840 280145 234020 280795 ;
        RECT 233840 280145 234020 280795 ;
        RECT 233840 279105 234020 280145 ;
        RECT 233840 280145 234020 280795 ;
        RECT 233560 279105 233740 280145 ;
        RECT 233280 280145 233460 280795 ;
        RECT 233280 280145 233460 280795 ;
        RECT 233280 280145 233460 280795 ;
        RECT 233280 280145 233460 280795 ;
        RECT 233280 279105 233460 280145 ;
        RECT 233280 280145 233460 280795 ;
        RECT 233000 279105 233180 280145 ;
        RECT 232720 280145 232900 280795 ;
        RECT 232720 280145 232900 280795 ;
        RECT 232720 280145 232900 280795 ;
        RECT 232720 280145 232900 280795 ;
        RECT 232720 279105 232900 280145 ;
        RECT 232720 280145 232900 280795 ;
        RECT 232440 279105 232620 280145 ;
        RECT 232160 280145 232340 280795 ;
        RECT 232160 280145 232340 280795 ;
        RECT 232160 280145 232340 280795 ;
        RECT 232160 280145 232340 280795 ;
        RECT 232160 279105 232340 280145 ;
        RECT 232160 280145 232340 280795 ;
        RECT 231880 279105 232060 280145 ;
        RECT 231600 280145 231780 280795 ;
        RECT 231600 280145 231780 280795 ;
        RECT 231600 280145 231780 280795 ;
        RECT 231600 280145 231780 280795 ;
        RECT 231600 279105 231780 280145 ;
        RECT 231600 280145 231780 280795 ;
        RECT 231320 279105 231500 280145 ;
        RECT 231040 280145 231220 280795 ;
        RECT 231040 280145 231220 280795 ;
        RECT 231040 280145 231220 280795 ;
        RECT 231040 280145 231220 280795 ;
        RECT 231040 279105 231220 280145 ;
        RECT 231040 280145 231220 280795 ;
        RECT 230760 279105 230940 280145 ;
        RECT 230480 280145 230660 280795 ;
        RECT 230480 280145 230660 280795 ;
        RECT 230480 280145 230660 280795 ;
        RECT 230480 280145 230660 280795 ;
        RECT 230480 279105 230660 280145 ;
        RECT 230480 280145 230660 280795 ;
        RECT 230400 278465 234660 278825 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234400 280795 234580 281835 ;
        RECT 234120 280795 234300 281835 ;
        RECT 233840 280795 234020 281835 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233280 280795 233460 281835 ;
        RECT 233000 280795 233180 281835 ;
        RECT 232720 280795 232900 281835 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232160 280795 232340 281835 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231600 280795 231780 281835 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231040 280795 231220 281835 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230480 280795 230660 281835 ;
        RECT 176062 129597 288998 242533 ;
      LAYER M5 ;
        RECT 234680 279105 234860 280145 ;
        RECT 230200 279105 230380 280145 ;
        RECT 234400 280145 234580 280795 ;
        RECT 234400 280145 234580 280795 ;
        RECT 234400 280145 234580 280795 ;
        RECT 234400 280145 234580 280795 ;
        RECT 234400 280145 234580 280795 ;
        RECT 234400 279105 234580 280145 ;
        RECT 234120 279105 234300 280145 ;
        RECT 233840 280145 234020 280795 ;
        RECT 233840 280145 234020 280795 ;
        RECT 233840 280145 234020 280795 ;
        RECT 233840 280145 234020 280795 ;
        RECT 233840 280145 234020 280795 ;
        RECT 233840 279105 234020 280145 ;
        RECT 233560 279105 233740 280145 ;
        RECT 233280 280145 233460 280795 ;
        RECT 233280 280145 233460 280795 ;
        RECT 233280 280145 233460 280795 ;
        RECT 233280 280145 233460 280795 ;
        RECT 233280 280145 233460 280795 ;
        RECT 233280 279105 233460 280145 ;
        RECT 233000 279105 233180 280145 ;
        RECT 232720 280145 232900 280795 ;
        RECT 232720 280145 232900 280795 ;
        RECT 232720 280145 232900 280795 ;
        RECT 232720 280145 232900 280795 ;
        RECT 232720 280145 232900 280795 ;
        RECT 232720 279105 232900 280145 ;
        RECT 232440 279105 232620 280145 ;
        RECT 232160 280145 232340 280795 ;
        RECT 232160 280145 232340 280795 ;
        RECT 232160 280145 232340 280795 ;
        RECT 232160 280145 232340 280795 ;
        RECT 232160 280145 232340 280795 ;
        RECT 232160 279105 232340 280145 ;
        RECT 231880 279105 232060 280145 ;
        RECT 231600 280145 231780 280795 ;
        RECT 231600 280145 231780 280795 ;
        RECT 231600 280145 231780 280795 ;
        RECT 231600 280145 231780 280795 ;
        RECT 231600 280145 231780 280795 ;
        RECT 231600 279105 231780 280145 ;
        RECT 231320 279105 231500 280145 ;
        RECT 231040 280145 231220 280795 ;
        RECT 231040 280145 231220 280795 ;
        RECT 231040 280145 231220 280795 ;
        RECT 231040 280145 231220 280795 ;
        RECT 231040 280145 231220 280795 ;
        RECT 231040 279105 231220 280145 ;
        RECT 230760 279105 230940 280145 ;
        RECT 230480 280145 230660 280795 ;
        RECT 230480 280145 230660 280795 ;
        RECT 230480 280145 230660 280795 ;
        RECT 230480 280145 230660 280795 ;
        RECT 230480 280145 230660 280795 ;
        RECT 230480 279105 230660 280145 ;
        RECT 230400 278285 234660 278645 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282485 ;
        RECT 230200 281835 230380 282995 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234400 280795 234580 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 280795 234300 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 233840 280795 234020 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233280 280795 233460 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 280795 233180 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 232720 280795 232900 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232160 280795 232340 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231600 280795 231780 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231040 280795 231220 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230480 280795 230660 281835 ;
        RECT 230200 282995 234860 283525 ;
        RECT 176062 129597 288998 242533 ;
        RECT 87560 175405 88760 196725 ;
        RECT 77500 185465 98820 186665 ;
        RECT 89360 187865 90560 196725 ;
        RECT 89360 187265 98820 188465 ;
        RECT 91160 189665 92360 196725 ;
        RECT 91160 189065 98820 190265 ;
        RECT 92960 191465 94160 196725 ;
        RECT 92960 190865 98820 192065 ;
        RECT 94760 193265 95960 196725 ;
        RECT 94760 192665 98820 193865 ;
        RECT 96560 195065 97760 196725 ;
        RECT 96560 194465 98820 195665 ;
        RECT 98360 196265 98820 196725 ;
        RECT 85760 187865 86960 196725 ;
        RECT 77500 187265 86960 188465 ;
        RECT 83960 189665 85160 196725 ;
        RECT 77500 189065 85160 190265 ;
        RECT 82160 191465 83360 196725 ;
        RECT 77500 190865 83360 192065 ;
        RECT 80360 193265 81560 196725 ;
        RECT 77500 192665 81560 193865 ;
        RECT 78560 195065 79760 196725 ;
        RECT 77500 194465 79760 195665 ;
        RECT 77500 196265 77960 196725 ;
        RECT 85760 175405 86960 184265 ;
        RECT 77500 183665 86960 184865 ;
        RECT 83960 175405 85160 182465 ;
        RECT 77500 181865 85160 183065 ;
        RECT 82160 175405 83360 180665 ;
        RECT 77500 180065 83360 181265 ;
        RECT 80360 175405 81560 178865 ;
        RECT 77500 178265 81560 179465 ;
        RECT 78560 175405 79760 177065 ;
        RECT 77500 176465 79760 177665 ;
        RECT 77500 175405 77960 175865 ;
        RECT 89360 175405 90560 184265 ;
        RECT 89360 183665 98820 184865 ;
        RECT 91160 175405 92360 182465 ;
        RECT 91160 181865 98820 183065 ;
        RECT 92960 175405 94160 180665 ;
        RECT 92960 180065 98820 181265 ;
        RECT 94760 175405 95960 178865 ;
        RECT 94760 178265 98820 179465 ;
        RECT 96560 175405 97760 177065 ;
        RECT 96560 176465 98820 177665 ;
        RECT 98360 175405 98820 175865 ;
        RECT 77500 196295 98820 196725 ;
        RECT 77500 175405 98820 175835 ;
        RECT 229205 304894 244865 306094 ;
        RECT 236435 297664 237635 313324 ;
        RECT 238835 303094 244865 304294 ;
        RECT 238235 297664 239435 304294 ;
        RECT 240635 301294 244865 302494 ;
        RECT 240035 297664 241235 302494 ;
        RECT 242435 299494 244865 300694 ;
        RECT 241835 297664 243035 300694 ;
        RECT 244235 297694 244865 298894 ;
        RECT 243635 297664 244835 298894 ;
        RECT 238835 306694 244865 307894 ;
        RECT 238235 306694 239435 313324 ;
        RECT 240635 308494 244865 309694 ;
        RECT 240035 308494 241235 313324 ;
        RECT 242435 310294 244865 311494 ;
        RECT 241835 310294 243035 313324 ;
        RECT 244235 312094 244865 313294 ;
        RECT 243635 312094 244835 313324 ;
        RECT 229205 306694 235235 307894 ;
        RECT 234635 306694 235835 313324 ;
        RECT 229205 308494 233435 309694 ;
        RECT 232835 308494 234035 313324 ;
        RECT 229205 310294 231635 311494 ;
        RECT 231035 310294 232235 313324 ;
        RECT 229205 312094 229835 313294 ;
        RECT 229235 312094 230435 313324 ;
        RECT 229205 303094 235235 304294 ;
        RECT 234635 297664 235835 304294 ;
        RECT 229205 301294 233435 302494 ;
        RECT 232835 297664 234035 302494 ;
        RECT 229205 299494 231635 300694 ;
        RECT 231035 297664 232235 300694 ;
        RECT 229205 297694 229835 298894 ;
        RECT 229235 297664 230435 298894 ;
        RECT 244435 297664 244865 313324 ;
        RECT 229205 297664 229635 313324 ;
      LAYER M6 ;
        RECT 234680 279105 234860 280145 ;
        RECT 230200 279105 230380 280145 ;
        RECT 234120 279105 234300 280145 ;
        RECT 234120 279105 234300 280145 ;
        RECT 234120 279105 234300 280145 ;
        RECT 234120 279105 234300 280145 ;
        RECT 234120 279105 234300 280145 ;
        RECT 233560 279105 233740 280145 ;
        RECT 233560 279105 233740 280145 ;
        RECT 233560 279105 233740 280145 ;
        RECT 233560 279105 233740 280145 ;
        RECT 233560 279105 233740 280145 ;
        RECT 233000 279105 233180 280145 ;
        RECT 233000 279105 233180 280145 ;
        RECT 233000 279105 233180 280145 ;
        RECT 233000 279105 233180 280145 ;
        RECT 233000 279105 233180 280145 ;
        RECT 232440 279105 232620 280145 ;
        RECT 232440 279105 232620 280145 ;
        RECT 232440 279105 232620 280145 ;
        RECT 232440 279105 232620 280145 ;
        RECT 232440 279105 232620 280145 ;
        RECT 231880 279105 232060 280145 ;
        RECT 231880 279105 232060 280145 ;
        RECT 231880 279105 232060 280145 ;
        RECT 231880 279105 232060 280145 ;
        RECT 231880 279105 232060 280145 ;
        RECT 231320 279105 231500 280145 ;
        RECT 231320 279105 231500 280145 ;
        RECT 231320 279105 231500 280145 ;
        RECT 231320 279105 231500 280145 ;
        RECT 231320 279105 231500 280145 ;
        RECT 230760 279105 230940 280145 ;
        RECT 230760 279105 230940 280145 ;
        RECT 230760 279105 230940 280145 ;
        RECT 230760 279105 230940 280145 ;
        RECT 230760 279105 230940 280145 ;
        RECT 230400 278105 234660 278465 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282485 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234120 280795 234300 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 280795 234300 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 280795 234300 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 280795 234300 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 280795 234300 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233000 280795 233180 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 280795 233180 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 280795 233180 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 280795 233180 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 280795 233180 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230200 282995 234860 283525 ;
        RECT 176062 129597 288998 242533 ;
        RECT 88460 186965 89660 196725 ;
        RECT 88460 186365 98820 187565 ;
        RECT 90260 188765 91460 196725 ;
        RECT 90260 188165 98820 189365 ;
        RECT 92060 190565 93260 196725 ;
        RECT 92060 189965 98820 191165 ;
        RECT 93860 192365 95060 196725 ;
        RECT 93860 191765 98820 192965 ;
        RECT 95660 194165 96860 196725 ;
        RECT 95660 193565 98820 194765 ;
        RECT 97460 195965 98660 196725 ;
        RECT 97460 195365 98820 196565 ;
        RECT 86660 186965 87860 196725 ;
        RECT 77500 186365 87860 187565 ;
        RECT 84860 188765 86060 196725 ;
        RECT 77500 188165 86060 189365 ;
        RECT 83060 190565 84260 196725 ;
        RECT 77500 189965 84260 191165 ;
        RECT 81260 192365 82460 196725 ;
        RECT 77500 191765 82460 192965 ;
        RECT 79460 194165 80660 196725 ;
        RECT 77500 193565 80660 194765 ;
        RECT 77660 195965 78860 196725 ;
        RECT 77500 195365 78860 196565 ;
        RECT 86660 175405 87860 185165 ;
        RECT 77500 184565 87860 185765 ;
        RECT 84860 175405 86060 183365 ;
        RECT 77500 182765 86060 183965 ;
        RECT 83060 175405 84260 181565 ;
        RECT 77500 180965 84260 182165 ;
        RECT 81260 175405 82460 179765 ;
        RECT 77500 179165 82460 180365 ;
        RECT 79460 175405 80660 177965 ;
        RECT 77500 177365 80660 178565 ;
        RECT 77660 175405 78860 176165 ;
        RECT 77500 175565 78860 176765 ;
        RECT 88460 175405 89660 185165 ;
        RECT 88460 184565 98820 185765 ;
        RECT 90260 175405 91460 183365 ;
        RECT 90260 182765 98820 183965 ;
        RECT 92060 175405 93260 181565 ;
        RECT 92060 180965 98820 182165 ;
        RECT 93860 175405 95060 179765 ;
        RECT 93860 179165 98820 180365 ;
        RECT 95660 175405 96860 177965 ;
        RECT 95660 177365 98820 178565 ;
        RECT 97460 175405 98660 176165 ;
        RECT 97460 175565 98820 176765 ;
        RECT 77500 196295 98820 196725 ;
        RECT 77500 175405 98820 175835 ;
        RECT 237935 303994 244865 305194 ;
        RECT 237335 297664 238535 305194 ;
        RECT 239735 302194 244865 303394 ;
        RECT 239135 297664 240335 303394 ;
        RECT 241535 300394 244865 301594 ;
        RECT 240935 297664 242135 301594 ;
        RECT 243335 298594 244865 299794 ;
        RECT 242735 297664 243935 299794 ;
        RECT 237935 305794 244865 306994 ;
        RECT 237335 305794 238535 313324 ;
        RECT 239735 307594 244865 308794 ;
        RECT 239135 307594 240335 313324 ;
        RECT 241535 309394 244865 310594 ;
        RECT 240935 309394 242135 313324 ;
        RECT 243335 311194 244865 312394 ;
        RECT 242735 311194 243935 313324 ;
        RECT 229205 305794 236135 306994 ;
        RECT 235535 305794 236735 313324 ;
        RECT 229205 307594 234335 308794 ;
        RECT 233735 307594 234935 313324 ;
        RECT 229205 309394 232535 310594 ;
        RECT 231935 309394 233135 313324 ;
        RECT 229205 311194 230735 312394 ;
        RECT 230135 311194 231335 313324 ;
        RECT 229205 303994 236135 305194 ;
        RECT 235535 297664 236735 305194 ;
        RECT 229205 302194 234335 303394 ;
        RECT 233735 297664 234935 303394 ;
        RECT 229205 300394 232535 301594 ;
        RECT 231935 297664 233135 301594 ;
        RECT 229205 298594 230735 299794 ;
        RECT 230135 297664 231335 299794 ;
        RECT 244435 297664 244865 313324 ;
        RECT 229205 297664 229635 313324 ;
      LAYER M7 ;
        RECT 230200 279105 236025 280145 ;
        RECT 230400 277585 234660 278285 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282485 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234680 280795 234860 281835 ;
        RECT 230200 280795 230380 281835 ;
        RECT 234680 281835 234860 282995 ;
        RECT 230200 281835 230380 282995 ;
        RECT 234120 280795 234300 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 280795 234300 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 280795 234300 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 280795 234300 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 234120 280795 234300 281835 ;
        RECT 234120 281835 234300 282995 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233560 280795 233740 281835 ;
        RECT 233560 281835 233740 282995 ;
        RECT 233000 280795 233180 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 280795 233180 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 280795 233180 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 280795 233180 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 233000 280795 233180 281835 ;
        RECT 233000 281835 233180 282995 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 232440 280795 232620 281835 ;
        RECT 232440 281835 232620 282995 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231880 280795 232060 281835 ;
        RECT 231880 281835 232060 282995 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 231320 280795 231500 281835 ;
        RECT 231320 281835 231500 282995 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230760 280795 230940 281835 ;
        RECT 230760 281835 230940 282995 ;
        RECT 230200 282995 234860 283525 ;
        RECT 176062 129597 288998 242533 ;
      LAYER M8 ;
        RECT 240090 330824 290090 390824 ;
        RECT 241880 334014 288300 387634 ;
        RECT 230400 277245 234660 278285 ;
        RECT 230200 282995 234860 284235 ;
        RECT 193070 183315 214570 188815 ;
        RECT 176062 129597 288998 242533 ;
        RECT 160060 330824 210060 390824 ;
        RECT 161850 334014 208270 387634 ;
        RECT 0 240090 60000 290090 ;
        RECT 3190 241880 56810 288300 ;
        RECT 320120 330824 370120 390824 ;
        RECT 321910 334014 368330 387634 ;
        RECT 0 160060 60000 210060 ;
        RECT 3190 161850 56810 208270 ;
        RECT 80030 330824 130030 390824 ;
        RECT 81820 334014 128240 387634 ;
        RECT 227825 285995 229285 292485 ;
        RECT 235775 285995 237235 292485 ;
        RECT 229285 285995 235775 286835 ;
        RECT 231800 287675 233260 294165 ;
        RECT 230265 287815 234795 289275 ;
        RECT 230265 290885 234795 292345 ;
        RECT 77500 188085 98820 196725 ;
        RECT 77500 175405 98820 184045 ;
        RECT 98820 195065 101320 196725 ;
        RECT 98820 175405 101320 177065 ;
        RECT 99660 175405 101320 196725 ;
        RECT 75000 184885 98820 187245 ;
        RECT 80000 187245 81740 194225 ;
        RECT 80000 187245 81740 194225 ;
        RECT 80000 177905 81740 184885 ;
        RECT 82916 187245 84656 194225 ;
        RECT 82916 187245 84656 194225 ;
        RECT 82916 177905 84656 184885 ;
        RECT 85832 187245 87572 194225 ;
        RECT 85832 187245 87572 194225 ;
        RECT 85832 177905 87572 184885 ;
        RECT 88748 187245 90488 194225 ;
        RECT 88748 187245 90488 194225 ;
        RECT 88748 177905 90488 184885 ;
        RECT 91664 187245 93404 194225 ;
        RECT 91664 187245 93404 194225 ;
        RECT 91664 177905 93404 184885 ;
        RECT 94580 187245 96320 194225 ;
        RECT 94580 187245 96320 194225 ;
        RECT 94580 177905 96320 184885 ;
        RECT 239055 297664 244865 313324 ;
        RECT 229205 297664 235015 313324 ;
        RECT 243205 295164 244865 297664 ;
        RECT 229205 295164 230865 297664 ;
        RECT 229205 295164 244865 296824 ;
        RECT 235855 297664 238215 315824 ;
        RECT 238215 309084 242365 310824 ;
        RECT 238215 309084 242365 310824 ;
        RECT 231705 309084 235855 310824 ;
        RECT 238215 306111 242365 307851 ;
        RECT 238215 306111 242365 307851 ;
        RECT 231705 306111 235855 307851 ;
        RECT 238215 303137 242365 304877 ;
        RECT 238215 303137 242365 304877 ;
        RECT 231705 303137 235855 304877 ;
        RECT 238215 300164 242365 301904 ;
        RECT 238215 300164 242365 301904 ;
        RECT 231705 300164 235855 301904 ;
        RECT 102320 167940 167320 170840 ;
        RECT 102320 201290 167320 204190 ;
        RECT 165320 167940 167320 204190 ;
        RECT 162320 167940 164320 204190 ;
        RECT 159320 167940 161320 204190 ;
        RECT 156320 167940 158320 204190 ;
        RECT 153320 167940 155320 204190 ;
        RECT 150320 167940 152320 204190 ;
        RECT 147320 167940 149320 204190 ;
        RECT 144320 167940 146320 204190 ;
        RECT 141320 167940 143320 204190 ;
        RECT 138320 167940 140320 204190 ;
        RECT 135320 167940 137320 204190 ;
        RECT 132320 167940 134320 204190 ;
        RECT 129320 167940 131320 204190 ;
        RECT 126320 167940 128320 204190 ;
        RECT 123320 167940 125320 204190 ;
        RECT 120320 167940 122320 204190 ;
        RECT 117320 167940 119320 204190 ;
        RECT 114320 167940 116320 204190 ;
        RECT 111320 167940 113320 204190 ;
        RECT 108320 167940 110320 204190 ;
        RECT 105320 167940 107320 204190 ;
        RECT 102320 167940 104320 204190 ;
      LAYER M9 ;
        RECT 240090 330824 290090 390824 ;
        RECT 241660 333794 288520 387854 ;
        RECT 230400 276465 234660 278465 ;
        RECT 230200 282995 234860 284995 ;
        RECT 141725 284915 226725 287915 ;
        RECT 168320 183315 198570 188815 ;
        RECT 201070 152605 263990 219525 ;
        RECT 229780 214025 235280 252275 ;
        RECT 176062 129597 288998 242533 ;
        RECT 160060 330824 210060 390824 ;
        RECT 161630 333794 208490 387854 ;
        RECT 0 240090 60000 290090 ;
        RECT 2970 241660 57030 288520 ;
        RECT 320120 330824 370120 390824 ;
        RECT 321690 333794 368550 387854 ;
        RECT 0 160060 60000 210060 ;
        RECT 2970 161630 57030 208490 ;
        RECT 245865 275125 340865 284125 ;
        RECT 80030 330824 130030 390824 ;
        RECT 81600 333794 128460 387854 ;
        RECT 104655 181330 164985 190800 ;
        RECT 104655 168940 164985 177410 ;
        RECT 104655 194720 164985 203190 ;
        RECT 102320 167940 167320 170840 ;
        RECT 102320 201290 167320 204190 ;
    END
END lna

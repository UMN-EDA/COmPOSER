MACRO CShunt_D_1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CShunt_D_1_1 0 0 ;
  SIZE 7740 BY 9180 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 9080 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 6460 3860 7740 5320 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 7620 6060 9080 ;
    LAYER M8 ;
      RECT 0 100 6060 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 7620 ;
    LAYER M8 ;
      RECT 1680 3860 7740 5320 ;
    LAYER M8 ;
      RECT 1820 2540 3280 6640 ;
    LAYER M8 ;
      RECT 4460 2540 5920 6640 ;
  END
END CShunt_D_1_1

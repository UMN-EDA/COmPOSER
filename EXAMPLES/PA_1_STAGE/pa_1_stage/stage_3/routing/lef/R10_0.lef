MACRO R10_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R10_0 0 0 ;
  SIZE 2280 BY 9510 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 9290 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1960 220 2050 9290 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 2080 9290 ;
    LAYER RPO ;
      RECT 540 0 1740 9510 ;
    LAYER M1 ;
      RECT 230 235 320 9275 ;
    LAYER M1 ;
      RECT 1960 235 2050 9275 ;
    LAYER RH ;
      RECT 0 20 2280 9490 ;
  END
END R10_0

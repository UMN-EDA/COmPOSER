MACRO R10_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R10_1 0 0 ;
  SIZE 2080 BY 8020 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 7800 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1760 220 1850 7800 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 1880 7800 ;
    LAYER RPO ;
      RECT 540 0 1540 8020 ;
    LAYER M1 ;
      RECT 230 235 320 7785 ;
    LAYER M1 ;
      RECT 1760 235 1850 7785 ;
    LAYER RH ;
      RECT 0 20 2080 8000 ;
  END
END R10_1

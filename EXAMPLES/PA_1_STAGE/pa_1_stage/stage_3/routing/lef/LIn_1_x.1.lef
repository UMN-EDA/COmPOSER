MACRO LIn_1_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_1_x.1 0 0 ;
  SIZE 133070 BY 122920 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 127570 63020 133070 68520 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 127570 54400 133070 59900 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 112570 56460 122570 66460 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 77570 63020 100320 68520 ;
    LAYER M8 ;
      RECT 0 0 122920 122920 ;
    LAYER M9 ;
      RECT 94820 63020 133070 68520 ;
    LAYER M9 ;
      RECT 22600 24755 100320 98165 ;
    LAYER M9 ;
      RECT 94820 54400 133070 59900 ;
    LAYER M9 ;
      RECT 0 0 122920 122920 ;
    LAYER M1 ;
      RECT 0 0 122920 122920 ;
    LAYER M2 ;
      RECT 0 0 122920 122920 ;
    LAYER M3 ;
      RECT 0 0 122920 122920 ;
    LAYER M4 ;
      RECT 0 0 122920 122920 ;
    LAYER M5 ;
      RECT 0 0 122920 122920 ;
    LAYER M6 ;
      RECT 0 0 122920 122920 ;
    LAYER M7 ;
      RECT 0 0 122920 122920 ;
  END
END LIn_1_x.1

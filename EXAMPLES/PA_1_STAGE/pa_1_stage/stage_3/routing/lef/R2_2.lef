MACRO R2_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R2_2 0 0 ;
  SIZE 16790 BY 4400 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 4180 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 16470 220 16560 4180 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 16590 4180 ;
    LAYER RPO ;
      RECT 540 0 16250 4400 ;
    LAYER M1 ;
      RECT 230 235 320 4165 ;
    LAYER M1 ;
      RECT 16470 235 16560 4165 ;
    LAYER RH ;
      RECT 0 20 16790 4380 ;
  END
END R2_2

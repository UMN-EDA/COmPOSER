MACRO LD_1_x.25
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_1_x.25 0 0 ;
  SIZE 112332 BY 113617 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 109332 51817 112332 54817 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 51817 110617 54817 113617 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 95617 48317 105617 58317 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 72707 51817 85957 54817 ;
    LAYER M8 ;
      RECT 0 0 106634 106634 ;
    LAYER M9 ;
      RECT 82957 51817 112332 54817 ;
    LAYER M9 ;
      RECT 25802 24517 80832 82117 ;
    LAYER M9 ;
      RECT 51817 79117 54817 113617 ;
    LAYER M9 ;
      RECT 0 0 106634 106634 ;
    LAYER M1 ;
      RECT 0 0 106634 106634 ;
    LAYER M2 ;
      RECT 0 0 106634 106634 ;
    LAYER M3 ;
      RECT 0 0 106634 106634 ;
    LAYER M4 ;
      RECT 0 0 106634 106634 ;
    LAYER M5 ;
      RECT 0 0 106634 106634 ;
    LAYER M6 ;
      RECT 0 0 106634 106634 ;
    LAYER M7 ;
      RECT 0 0 106634 106634 ;
  END
END LD_1_x.25

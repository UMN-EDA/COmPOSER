MACRO CSeries_D_1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CSeries_D_1_1 0 0 ;
  SIZE 17130 BY 12130 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6915 11700 10215 12130 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6915 0 10215 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 4885 1660 7245 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 15470 1760 17130 10370 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 8085 14630 12130 ;
    LAYER M8 ;
      RECT 2500 0 14630 4045 ;
    LAYER M8 ;
      RECT 14630 10470 17130 12130 ;
    LAYER M8 ;
      RECT 14630 0 17130 1660 ;
    LAYER M8 ;
      RECT 15470 0 17130 12130 ;
    LAYER M8 ;
      RECT 0 4885 14630 7245 ;
    LAYER M8 ;
      RECT 5000 7245 6740 9630 ;
    LAYER M8 ;
      RECT 5000 7245 6740 9630 ;
    LAYER M8 ;
      RECT 5000 2500 6740 4885 ;
    LAYER M8 ;
      RECT 7695 7245 9435 9630 ;
    LAYER M8 ;
      RECT 7695 7245 9435 9630 ;
    LAYER M8 ;
      RECT 7695 2500 9435 4885 ;
    LAYER M8 ;
      RECT 10390 7245 12130 9630 ;
    LAYER M8 ;
      RECT 10390 7245 12130 9630 ;
    LAYER M8 ;
      RECT 10390 2500 12130 4885 ;
    LAYER M5 ;
      RECT 7965 0 9165 12130 ;
    LAYER M5 ;
      RECT 2500 5465 14630 6665 ;
    LAYER M5 ;
      RECT 9765 7865 10965 12130 ;
    LAYER M5 ;
      RECT 9765 7265 14630 8465 ;
    LAYER M5 ;
      RECT 11565 9665 12765 12130 ;
    LAYER M5 ;
      RECT 11565 9065 14630 10265 ;
    LAYER M5 ;
      RECT 13365 11465 14565 12130 ;
    LAYER M5 ;
      RECT 13365 10865 14630 12065 ;
    LAYER M5 ;
      RECT 6165 7865 7365 12130 ;
    LAYER M5 ;
      RECT 2500 7265 7365 8465 ;
    LAYER M5 ;
      RECT 4365 9665 5565 12130 ;
    LAYER M5 ;
      RECT 2500 9065 5565 10265 ;
    LAYER M5 ;
      RECT 2565 11465 3765 12130 ;
    LAYER M5 ;
      RECT 2500 10865 3765 12065 ;
    LAYER M5 ;
      RECT 6165 0 7365 4265 ;
    LAYER M5 ;
      RECT 2500 3665 7365 4865 ;
    LAYER M5 ;
      RECT 4365 0 5565 2465 ;
    LAYER M5 ;
      RECT 2500 1865 5565 3065 ;
    LAYER M5 ;
      RECT 2565 0 3765 665 ;
    LAYER M5 ;
      RECT 2500 65 3765 1265 ;
    LAYER M5 ;
      RECT 9765 0 10965 4265 ;
    LAYER M5 ;
      RECT 9765 3665 14630 4865 ;
    LAYER M5 ;
      RECT 11565 0 12765 2465 ;
    LAYER M5 ;
      RECT 11565 1865 14630 3065 ;
    LAYER M5 ;
      RECT 13365 0 14565 665 ;
    LAYER M5 ;
      RECT 13365 65 14630 1265 ;
    LAYER M5 ;
      RECT 2500 11700 14630 12130 ;
    LAYER M5 ;
      RECT 2500 0 14630 430 ;
    LAYER M6 ;
      RECT 8865 6965 10065 12130 ;
    LAYER M6 ;
      RECT 8865 6365 14630 7565 ;
    LAYER M6 ;
      RECT 10665 8765 11865 12130 ;
    LAYER M6 ;
      RECT 10665 8165 14630 9365 ;
    LAYER M6 ;
      RECT 12465 10565 13665 12130 ;
    LAYER M6 ;
      RECT 12465 9965 14630 11165 ;
    LAYER M6 ;
      RECT 7065 6965 8265 12130 ;
    LAYER M6 ;
      RECT 2500 6365 8265 7565 ;
    LAYER M6 ;
      RECT 5265 8765 6465 12130 ;
    LAYER M6 ;
      RECT 2500 8165 6465 9365 ;
    LAYER M6 ;
      RECT 3465 10565 4665 12130 ;
    LAYER M6 ;
      RECT 2500 9965 4665 11165 ;
    LAYER M6 ;
      RECT 7065 0 8265 5165 ;
    LAYER M6 ;
      RECT 2500 4565 8265 5765 ;
    LAYER M6 ;
      RECT 5265 0 6465 3365 ;
    LAYER M6 ;
      RECT 2500 2765 6465 3965 ;
    LAYER M6 ;
      RECT 3465 0 4665 1565 ;
    LAYER M6 ;
      RECT 2500 965 4665 2165 ;
    LAYER M6 ;
      RECT 8865 0 10065 5165 ;
    LAYER M6 ;
      RECT 8865 4565 14630 5765 ;
    LAYER M6 ;
      RECT 10665 0 11865 3365 ;
    LAYER M6 ;
      RECT 10665 2765 14630 3965 ;
    LAYER M6 ;
      RECT 12465 0 13665 1565 ;
    LAYER M6 ;
      RECT 12465 965 14630 2165 ;
    LAYER M6 ;
      RECT 2500 11700 14630 12130 ;
    LAYER M6 ;
      RECT 2500 0 14630 430 ;
  END
END CSeries_D_1_1

MACRO xc2_3
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc2_3 0 0 ;
  SIZE 18640 BY 33870 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 7418 33440 11222 33870 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 7418 0 11222 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 15755 1660 18115 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 16980 11875 18640 21995 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 18955 16140 33870 ;
    LAYER M8 ;
      RECT 2500 0 16140 14915 ;
    LAYER M8 ;
      RECT 16140 32210 18640 33870 ;
    LAYER M8 ;
      RECT 16140 0 18640 1660 ;
    LAYER M8 ;
      RECT 16980 0 18640 33870 ;
    LAYER M8 ;
      RECT 0 15755 16140 18115 ;
    LAYER M8 ;
      RECT 5000 18115 6740 31370 ;
    LAYER M8 ;
      RECT 5000 18115 6740 31370 ;
    LAYER M8 ;
      RECT 5000 2500 6740 15755 ;
    LAYER M8 ;
      RECT 8450 18115 10190 31370 ;
    LAYER M8 ;
      RECT 8450 18115 10190 31370 ;
    LAYER M8 ;
      RECT 8450 2500 10190 15755 ;
    LAYER M8 ;
      RECT 11900 18115 13640 31370 ;
    LAYER M8 ;
      RECT 11900 18115 13640 31370 ;
    LAYER M8 ;
      RECT 11900 2500 13640 15755 ;
    LAYER M5 ;
      RECT 8720 0 9920 33870 ;
    LAYER M5 ;
      RECT 2500 16335 16140 17535 ;
    LAYER M5 ;
      RECT 10520 18735 11720 33870 ;
    LAYER M5 ;
      RECT 10520 18135 16140 19335 ;
    LAYER M5 ;
      RECT 12320 20535 13520 33870 ;
    LAYER M5 ;
      RECT 12320 19935 16140 21135 ;
    LAYER M5 ;
      RECT 14120 22335 15320 33870 ;
    LAYER M5 ;
      RECT 14120 21735 16140 22935 ;
    LAYER M5 ;
      RECT 15920 24135 16140 33870 ;
    LAYER M5 ;
      RECT 15920 23535 16140 24735 ;
    LAYER M5 ;
      RECT 6920 18735 8120 33870 ;
    LAYER M5 ;
      RECT 2500 18135 8120 19335 ;
    LAYER M5 ;
      RECT 5120 20535 6320 33870 ;
    LAYER M5 ;
      RECT 2500 19935 6320 21135 ;
    LAYER M5 ;
      RECT 3320 22335 4520 33870 ;
    LAYER M5 ;
      RECT 2500 21735 4520 22935 ;
    LAYER M5 ;
      RECT 2500 24135 2720 33870 ;
    LAYER M5 ;
      RECT 2500 23535 2720 24735 ;
    LAYER M5 ;
      RECT 6920 0 8120 15135 ;
    LAYER M5 ;
      RECT 2500 14535 8120 15735 ;
    LAYER M5 ;
      RECT 5120 0 6320 13335 ;
    LAYER M5 ;
      RECT 2500 12735 6320 13935 ;
    LAYER M5 ;
      RECT 3320 0 4520 11535 ;
    LAYER M5 ;
      RECT 2500 10935 4520 12135 ;
    LAYER M5 ;
      RECT 2500 0 2720 9735 ;
    LAYER M5 ;
      RECT 2500 9135 2720 10335 ;
    LAYER M5 ;
      RECT 10520 0 11720 15135 ;
    LAYER M5 ;
      RECT 10520 14535 16140 15735 ;
    LAYER M5 ;
      RECT 12320 0 13520 13335 ;
    LAYER M5 ;
      RECT 12320 12735 16140 13935 ;
    LAYER M5 ;
      RECT 14120 0 15320 11535 ;
    LAYER M5 ;
      RECT 14120 10935 16140 12135 ;
    LAYER M5 ;
      RECT 15920 0 16140 9735 ;
    LAYER M5 ;
      RECT 15920 9135 16140 10335 ;
    LAYER M5 ;
      RECT 2500 33440 16140 33870 ;
    LAYER M5 ;
      RECT 2500 0 16140 430 ;
    LAYER M6 ;
      RECT 9620 17835 10820 33870 ;
    LAYER M6 ;
      RECT 9620 17235 16140 18435 ;
    LAYER M6 ;
      RECT 11420 19635 12620 33870 ;
    LAYER M6 ;
      RECT 11420 19035 16140 20235 ;
    LAYER M6 ;
      RECT 13220 21435 14420 33870 ;
    LAYER M6 ;
      RECT 13220 20835 16140 22035 ;
    LAYER M6 ;
      RECT 15020 23235 16140 33870 ;
    LAYER M6 ;
      RECT 15020 22635 16140 23835 ;
    LAYER M6 ;
      RECT 7820 17835 9020 33870 ;
    LAYER M6 ;
      RECT 2500 17235 9020 18435 ;
    LAYER M6 ;
      RECT 6020 19635 7220 33870 ;
    LAYER M6 ;
      RECT 2500 19035 7220 20235 ;
    LAYER M6 ;
      RECT 4220 21435 5420 33870 ;
    LAYER M6 ;
      RECT 2500 20835 5420 22035 ;
    LAYER M6 ;
      RECT 2500 23235 3620 33870 ;
    LAYER M6 ;
      RECT 2500 22635 3620 23835 ;
    LAYER M6 ;
      RECT 7820 0 9020 16035 ;
    LAYER M6 ;
      RECT 2500 15435 9020 16635 ;
    LAYER M6 ;
      RECT 6020 0 7220 14235 ;
    LAYER M6 ;
      RECT 2500 13635 7220 14835 ;
    LAYER M6 ;
      RECT 4220 0 5420 12435 ;
    LAYER M6 ;
      RECT 2500 11835 5420 13035 ;
    LAYER M6 ;
      RECT 2500 0 3620 10635 ;
    LAYER M6 ;
      RECT 2500 10035 3620 11235 ;
    LAYER M6 ;
      RECT 9620 0 10820 16035 ;
    LAYER M6 ;
      RECT 9620 15435 16140 16635 ;
    LAYER M6 ;
      RECT 11420 0 12620 14235 ;
    LAYER M6 ;
      RECT 11420 13635 16140 14835 ;
    LAYER M6 ;
      RECT 13220 0 14420 12435 ;
    LAYER M6 ;
      RECT 13220 11835 16140 13035 ;
    LAYER M6 ;
      RECT 15020 0 16140 10635 ;
    LAYER M6 ;
      RECT 15020 10035 16140 11235 ;
    LAYER M6 ;
      RECT 2500 33440 16140 33870 ;
    LAYER M6 ;
      RECT 2500 0 16140 430 ;
  END
END xc2_3

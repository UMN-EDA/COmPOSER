MACRO xR0_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR0_2 0 0 ;
  SIZE 25540 BY 7840 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 7620 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 25220 220 25310 7620 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 25340 7620 ;
    LAYER RPO ;
      RECT 540 0 25000 7840 ;
    LAYER M1 ;
      RECT 230 235 320 7605 ;
    LAYER M1 ;
      RECT 25220 235 25310 7605 ;
    LAYER RH ;
      RECT 0 20 25540 7820 ;
  END
END xR0_2

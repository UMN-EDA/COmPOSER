MACRO xwg1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xwg1 0 0 ;
  SIZE 65000 BY 36265 ;
  PIN GND1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 27762 1000 37237 9475 ;
    END
  END GND1
  PIN GND2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 27762 26790 37237 35265 ;
    END
  END GND2
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 2500 13395 11975 22870 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 53025 13395 62500 22870 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 2500 13395 62500 22870 ;
    LAYER M9 ;
      RECT 2500 26790 62500 35265 ;
    LAYER M9 ;
      RECT 2500 1000 62500 9475 ;
    LAYER M9 ;
      RECT 0 33365 65000 36265 ;
    LAYER M9 ;
      RECT 0 0 65000 2900 ;
    LAYER M8 ;
      RECT 0 33365 65000 36265 ;
    LAYER M8 ;
      RECT 0 0 65000 2900 ;
    LAYER M8 ;
      RECT 0 0 2000 36265 ;
    LAYER M8 ;
      RECT 3000 0 5000 36265 ;
    LAYER M8 ;
      RECT 6000 0 8000 36265 ;
    LAYER M8 ;
      RECT 9000 0 11000 36265 ;
    LAYER M8 ;
      RECT 12000 0 14000 36265 ;
    LAYER M8 ;
      RECT 15000 0 17000 36265 ;
    LAYER M8 ;
      RECT 18000 0 20000 36265 ;
    LAYER M8 ;
      RECT 21000 0 23000 36265 ;
    LAYER M8 ;
      RECT 24000 0 26000 36265 ;
    LAYER M8 ;
      RECT 27000 0 29000 36265 ;
    LAYER M8 ;
      RECT 30000 0 32000 36265 ;
    LAYER M8 ;
      RECT 33000 0 35000 36265 ;
    LAYER M8 ;
      RECT 36000 0 38000 36265 ;
    LAYER M8 ;
      RECT 39000 0 41000 36265 ;
    LAYER M8 ;
      RECT 42000 0 44000 36265 ;
    LAYER M8 ;
      RECT 45000 0 47000 36265 ;
    LAYER M8 ;
      RECT 48000 0 50000 36265 ;
    LAYER M8 ;
      RECT 51000 0 53000 36265 ;
    LAYER M8 ;
      RECT 54000 0 56000 36265 ;
    LAYER M8 ;
      RECT 57000 0 59000 36265 ;
    LAYER M8 ;
      RECT 60000 0 62000 36265 ;
    LAYER M8 ;
      RECT 63000 0 65000 36265 ;
  END
END xwg1

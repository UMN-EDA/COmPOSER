MACRO gate_ind_x.5
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gate_ind_x.5 0 0 ;
  SIZE 140370 BY 119358 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 134370 56679 140370 62679 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 56679 6000 62679 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 119370 54679 129370 64679 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 92870 56679 115870 62679 ;
    LAYER M8 ;
      RECT 10506 0 129864 119358 ;
    LAYER M9 ;
      RECT 109870 56679 140370 62679 ;
    LAYER M9 ;
      RECT 33000 24619 107370 94739 ;
    LAYER M9 ;
      RECT 0 56679 39000 62679 ;
    LAYER M9 ;
      RECT 10506 0 129864 119358 ;
    LAYER M1 ;
      RECT 10506 0 129864 119358 ;
    LAYER M2 ;
      RECT 10506 0 129864 119358 ;
    LAYER M3 ;
      RECT 10506 0 129864 119358 ;
    LAYER M4 ;
      RECT 10506 0 129864 119358 ;
    LAYER M5 ;
      RECT 10506 0 129864 119358 ;
    LAYER M6 ;
      RECT 10506 0 129864 119358 ;
    LAYER M7 ;
      RECT 10506 0 129864 119358 ;
  END
END gate_ind_x.5

MACRO drain_ind_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN drain_ind_x.1 0 0 ;
  SIZE 194517 BY 187214 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 186017 94667 194517 103167 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 186017 84047 194517 92547 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 179517 88607 189517 98607 ;
    END
  END GND
  OBS
    LAYER M9 ;
      RECT 18447 18447 168767 168767 ;
    LAYER M9 ;
      RECT 160267 94667 194517 103167 ;
    LAYER M9 ;
      RECT 160267 84047 194517 92547 ;
    LAYER M9 ;
      RECT 0 0 187214 187214 ;
    LAYER M1 ;
      RECT 0 0 187214 187214 ;
    LAYER M2 ;
      RECT 0 0 187214 187214 ;
    LAYER M3 ;
      RECT 0 0 187214 187214 ;
    LAYER M4 ;
      RECT 0 0 187214 187214 ;
    LAYER M5 ;
      RECT 0 0 187214 187214 ;
    LAYER M6 ;
      RECT 0 0 187214 187214 ;
    LAYER M7 ;
      RECT 0 0 187214 187214 ;
    LAYER M8 ;
      RECT 0 0 187214 187214 ;
  END
END drain_ind_x.1

MACRO xwg1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xwg1 0 0 ;
  SIZE 62000 BY 36320 ;
  PIN GND1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 26260 1000 35740 9480 ;
    END
  END GND1
  PIN GND2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 26260 26840 35740 35320 ;
    END
  END GND2
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1485 13420 10965 22900 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 51035 13420 60515 22900 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 1485 13420 60515 22900 ;
    LAYER M9 ;
      RECT 1485 26840 60515 35320 ;
    LAYER M9 ;
      RECT 1485 1000 60515 9480 ;
    LAYER M9 ;
      RECT 0 33420 62000 36320 ;
    LAYER M9 ;
      RECT 0 0 62000 2900 ;
    LAYER M8 ;
      RECT 0 33420 62000 36320 ;
    LAYER M8 ;
      RECT 0 0 62000 2900 ;
    LAYER M8 ;
      RECT 0 0 2000 36320 ;
    LAYER M8 ;
      RECT 3000 0 5000 36320 ;
    LAYER M8 ;
      RECT 6000 0 8000 36320 ;
    LAYER M8 ;
      RECT 9000 0 11000 36320 ;
    LAYER M8 ;
      RECT 12000 0 14000 36320 ;
    LAYER M8 ;
      RECT 15000 0 17000 36320 ;
    LAYER M8 ;
      RECT 18000 0 20000 36320 ;
    LAYER M8 ;
      RECT 21000 0 23000 36320 ;
    LAYER M8 ;
      RECT 24000 0 26000 36320 ;
    LAYER M8 ;
      RECT 27000 0 29000 36320 ;
    LAYER M8 ;
      RECT 30000 0 32000 36320 ;
    LAYER M8 ;
      RECT 33000 0 35000 36320 ;
    LAYER M8 ;
      RECT 36000 0 38000 36320 ;
    LAYER M8 ;
      RECT 39000 0 41000 36320 ;
    LAYER M8 ;
      RECT 42000 0 44000 36320 ;
    LAYER M8 ;
      RECT 45000 0 47000 36320 ;
    LAYER M8 ;
      RECT 48000 0 50000 36320 ;
    LAYER M8 ;
      RECT 51000 0 53000 36320 ;
    LAYER M8 ;
      RECT 54000 0 56000 36320 ;
    LAYER M8 ;
      RECT 57000 0 59000 36320 ;
    LAYER M8 ;
      RECT 60000 0 62000 36320 ;
  END
END xwg1

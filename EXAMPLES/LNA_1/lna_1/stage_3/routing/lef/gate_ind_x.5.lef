MACRO gate_ind_x.5
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gate_ind_x.5 0 0 ;
  SIZE 141400 BY 125858 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 138400 61429 141400 64429 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 61429 3000 64429 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 123400 57929 133400 67929 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 95150 61429 115775 64429 ;
    LAYER M8 ;
      RECT 7771 0 133629 125858 ;
    LAYER M9 ;
      RECT 112775 61429 141400 64429 ;
    LAYER M9 ;
      RECT 31500 25194 109900 100664 ;
    LAYER M9 ;
      RECT 0 61429 34500 64429 ;
    LAYER M9 ;
      RECT 7771 0 133629 125858 ;
    LAYER M1 ;
      RECT 7771 0 133629 125858 ;
    LAYER M2 ;
      RECT 7771 0 133629 125858 ;
    LAYER M3 ;
      RECT 7771 0 133629 125858 ;
    LAYER M4 ;
      RECT 7771 0 133629 125858 ;
    LAYER M5 ;
      RECT 7771 0 133629 125858 ;
    LAYER M6 ;
      RECT 7771 0 133629 125858 ;
    LAYER M7 ;
      RECT 7771 0 133629 125858 ;
  END
END gate_ind_x.5

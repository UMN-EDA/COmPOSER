MACRO CShunt_D_1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CShunt_D_1_1 0 0 ;
  SIZE 7820 BY 9260 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 9160 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 6540 3900 7820 5360 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 7700 6140 9160 ;
    LAYER M8 ;
      RECT 0 100 6140 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 7700 ;
    LAYER M8 ;
      RECT 1680 3900 7820 5360 ;
    LAYER M8 ;
      RECT 1820 2540 3280 6720 ;
    LAYER M8 ;
      RECT 4540 2540 6000 6720 ;
  END
END CShunt_D_1_1

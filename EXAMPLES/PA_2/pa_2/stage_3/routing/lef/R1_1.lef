MACRO R1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN R1_1 0 0 ;
  SIZE 6250 BY 5330 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 5110 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 5930 220 6020 5110 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 6050 5110 ;
    LAYER RPO ;
      RECT 540 0 5710 5330 ;
    LAYER M1 ;
      RECT 230 235 320 5095 ;
    LAYER M1 ;
      RECT 5930 235 6020 5095 ;
    LAYER RH ;
      RECT 0 20 6250 5310 ;
  END
END R1_1

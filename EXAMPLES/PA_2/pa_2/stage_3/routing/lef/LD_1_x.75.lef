MACRO LD_1_x.75
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_1_x.75 0 0 ;
  SIZE 108127 BY 109627 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 104127 56705 108127 60705 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 48922 0 52922 4000 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 90627 53705 100627 63705 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 66127 56705 82127 60705 ;
    LAYER M8 ;
      RECT 0 7783 101844 109627 ;
    LAYER M9 ;
      RECT 78127 56705 108127 60705 ;
    LAYER M9 ;
      RECT 25717 32000 76127 85410 ;
    LAYER M9 ;
      RECT 48922 0 52922 36000 ;
    LAYER M9 ;
      RECT 0 7783 101844 109627 ;
    LAYER M1 ;
      RECT 0 7783 101844 109627 ;
    LAYER M2 ;
      RECT 0 7783 101844 109627 ;
    LAYER M3 ;
      RECT 0 7783 101844 109627 ;
    LAYER M4 ;
      RECT 0 7783 101844 109627 ;
    LAYER M5 ;
      RECT 0 7783 101844 109627 ;
    LAYER M6 ;
      RECT 0 7783 101844 109627 ;
    LAYER M7 ;
      RECT 0 7783 101844 109627 ;
  END
END LD_1_x.75

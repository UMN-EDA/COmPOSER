MACRO LD_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_2 0 0 ;
  SIZE 130000 BY 48500 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 8500 28500 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 121500 20000 130000 28500 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 130000 28500 ;
    LAYER M1 ;
      RECT 8500 0 121500 48500 ;
  END
END LD_2

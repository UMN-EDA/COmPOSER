MACRO LIn_2_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_2_x.1 0 0 ;
  SIZE 127416 BY 122772 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 124416 63196 127416 66196 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 124416 56576 127416 59576 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 112416 56386 122416 66386 ;
    END
  END GND
  OBS
    LAYER M9 ;
      RECT 23856 23856 98916 98916 ;
    LAYER M9 ;
      RECT 95916 63196 127416 66196 ;
    LAYER M9 ;
      RECT 95916 56576 127416 59576 ;
    LAYER M9 ;
      RECT 0 0 122772 122772 ;
    LAYER M1 ;
      RECT 0 0 122772 122772 ;
    LAYER M2 ;
      RECT 0 0 122772 122772 ;
    LAYER M3 ;
      RECT 0 0 122772 122772 ;
    LAYER M4 ;
      RECT 0 0 122772 122772 ;
    LAYER M5 ;
      RECT 0 0 122772 122772 ;
    LAYER M6 ;
      RECT 0 0 122772 122772 ;
    LAYER M7 ;
      RECT 0 0 122772 122772 ;
    LAYER M8 ;
      RECT 0 0 122772 122772 ;
  END
END LIn_2_x.1

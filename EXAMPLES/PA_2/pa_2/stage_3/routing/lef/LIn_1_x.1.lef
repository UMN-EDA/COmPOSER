MACRO LIn_1_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_1_x.1 0 0 ;
  SIZE 137126 BY 127772 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 132626 65511 137126 70011 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 132626 57761 137126 62261 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 117626 58886 127626 68886 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 84876 65511 104876 70011 ;
    LAYER M8 ;
      RECT 0 0 127772 127772 ;
    LAYER M9 ;
      RECT 100376 65511 137126 70011 ;
    LAYER M9 ;
      RECT 22896 24836 104876 102936 ;
    LAYER M9 ;
      RECT 100376 57761 137126 62261 ;
    LAYER M9 ;
      RECT 0 0 127772 127772 ;
    LAYER M1 ;
      RECT 0 0 127772 127772 ;
    LAYER M2 ;
      RECT 0 0 127772 127772 ;
    LAYER M3 ;
      RECT 0 0 127772 127772 ;
    LAYER M4 ;
      RECT 0 0 127772 127772 ;
    LAYER M5 ;
      RECT 0 0 127772 127772 ;
    LAYER M6 ;
      RECT 0 0 127772 127772 ;
    LAYER M7 ;
      RECT 0 0 127772 127772 ;
  END
END LIn_1_x.1

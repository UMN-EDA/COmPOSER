MACRO CSeries_D_1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CSeries_D_1_1 0 0 ;
  SIZE 8680 BY 10120 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 10020 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 7400 4330 8680 5790 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 8560 7000 10020 ;
    LAYER M8 ;
      RECT 0 100 7000 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 8560 ;
    LAYER M8 ;
      RECT 1680 4330 8680 5790 ;
    LAYER M8 ;
      RECT 1820 2540 3280 7580 ;
    LAYER M8 ;
      RECT 5400 2540 6860 7580 ;
  END
END CSeries_D_1_1

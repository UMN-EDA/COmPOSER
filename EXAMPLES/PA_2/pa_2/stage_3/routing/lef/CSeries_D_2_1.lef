MACRO CSeries_D_2_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CSeries_D_2_1 0 0 ;
  SIZE 17880 BY 12880 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 7165 12450 10715 12880 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 7165 0 10715 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 5260 1660 7620 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 16220 1760 17880 11120 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 8460 15380 12880 ;
    LAYER M8 ;
      RECT 2500 0 15380 4420 ;
    LAYER M8 ;
      RECT 15380 11220 17880 12880 ;
    LAYER M8 ;
      RECT 15380 0 17880 1660 ;
    LAYER M8 ;
      RECT 16220 0 17880 12880 ;
    LAYER M8 ;
      RECT 0 5260 15380 7620 ;
    LAYER M8 ;
      RECT 5000 7620 6740 10380 ;
    LAYER M8 ;
      RECT 5000 7620 6740 10380 ;
    LAYER M8 ;
      RECT 5000 2500 6740 5260 ;
    LAYER M8 ;
      RECT 8070 7620 9810 10380 ;
    LAYER M8 ;
      RECT 8070 7620 9810 10380 ;
    LAYER M8 ;
      RECT 8070 2500 9810 5260 ;
    LAYER M8 ;
      RECT 11140 7620 12880 10380 ;
    LAYER M8 ;
      RECT 11140 7620 12880 10380 ;
    LAYER M8 ;
      RECT 11140 2500 12880 5260 ;
    LAYER M5 ;
      RECT 8340 0 9540 12880 ;
    LAYER M5 ;
      RECT 2500 5840 15380 7040 ;
    LAYER M5 ;
      RECT 10140 8240 11340 12880 ;
    LAYER M5 ;
      RECT 10140 7640 15380 8840 ;
    LAYER M5 ;
      RECT 11940 10040 13140 12880 ;
    LAYER M5 ;
      RECT 11940 9440 15380 10640 ;
    LAYER M5 ;
      RECT 13740 11840 14940 12880 ;
    LAYER M5 ;
      RECT 13740 11240 15380 12440 ;
    LAYER M5 ;
      RECT 6540 8240 7740 12880 ;
    LAYER M5 ;
      RECT 2500 7640 7740 8840 ;
    LAYER M5 ;
      RECT 4740 10040 5940 12880 ;
    LAYER M5 ;
      RECT 2500 9440 5940 10640 ;
    LAYER M5 ;
      RECT 2940 11840 4140 12880 ;
    LAYER M5 ;
      RECT 2500 11240 4140 12440 ;
    LAYER M5 ;
      RECT 6540 0 7740 4640 ;
    LAYER M5 ;
      RECT 2500 4040 7740 5240 ;
    LAYER M5 ;
      RECT 4740 0 5940 2840 ;
    LAYER M5 ;
      RECT 2500 2240 5940 3440 ;
    LAYER M5 ;
      RECT 2940 0 4140 1040 ;
    LAYER M5 ;
      RECT 2500 440 4140 1640 ;
    LAYER M5 ;
      RECT 10140 0 11340 4640 ;
    LAYER M5 ;
      RECT 10140 4040 15380 5240 ;
    LAYER M5 ;
      RECT 11940 0 13140 2840 ;
    LAYER M5 ;
      RECT 11940 2240 15380 3440 ;
    LAYER M5 ;
      RECT 13740 0 14940 1040 ;
    LAYER M5 ;
      RECT 13740 440 15380 1640 ;
    LAYER M5 ;
      RECT 2500 12450 15380 12880 ;
    LAYER M5 ;
      RECT 2500 0 15380 430 ;
    LAYER M6 ;
      RECT 9240 7340 10440 12880 ;
    LAYER M6 ;
      RECT 9240 6740 15380 7940 ;
    LAYER M6 ;
      RECT 11040 9140 12240 12880 ;
    LAYER M6 ;
      RECT 11040 8540 15380 9740 ;
    LAYER M6 ;
      RECT 12840 10940 14040 12880 ;
    LAYER M6 ;
      RECT 12840 10340 15380 11540 ;
    LAYER M6 ;
      RECT 7440 7340 8640 12880 ;
    LAYER M6 ;
      RECT 2500 6740 8640 7940 ;
    LAYER M6 ;
      RECT 5640 9140 6840 12880 ;
    LAYER M6 ;
      RECT 2500 8540 6840 9740 ;
    LAYER M6 ;
      RECT 3840 10940 5040 12880 ;
    LAYER M6 ;
      RECT 2500 10340 5040 11540 ;
    LAYER M6 ;
      RECT 7440 0 8640 5540 ;
    LAYER M6 ;
      RECT 2500 4940 8640 6140 ;
    LAYER M6 ;
      RECT 5640 0 6840 3740 ;
    LAYER M6 ;
      RECT 2500 3140 6840 4340 ;
    LAYER M6 ;
      RECT 3840 0 5040 1940 ;
    LAYER M6 ;
      RECT 2500 1340 5040 2540 ;
    LAYER M6 ;
      RECT 9240 0 10440 5540 ;
    LAYER M6 ;
      RECT 9240 4940 15380 6140 ;
    LAYER M6 ;
      RECT 11040 0 12240 3740 ;
    LAYER M6 ;
      RECT 11040 3140 15380 4340 ;
    LAYER M6 ;
      RECT 12840 0 14040 1940 ;
    LAYER M6 ;
      RECT 12840 1340 15380 2540 ;
    LAYER M6 ;
      RECT 2500 12450 15380 12880 ;
    LAYER M6 ;
      RECT 2500 0 15380 430 ;
  END
END CSeries_D_2_1

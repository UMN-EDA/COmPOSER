MACRO drain_ind1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN drain_ind1 0 0 ;
  SIZE 100000 BY 42500 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 2500 22500 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 97500 20000 100000 22500 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 100000 22500 ;
    LAYER M1 ;
      RECT 2500 0 97500 42500 ;
  END
END drain_ind1

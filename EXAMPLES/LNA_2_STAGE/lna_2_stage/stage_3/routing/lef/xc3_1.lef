MACRO xc3_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc3_1 0 0 ;
  SIZE 20660 BY 15660 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 15230 12568 15660 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 8092 0 12568 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 6650 1660 9010 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 19000 1760 20660 13900 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 9850 18160 15660 ;
    LAYER M8 ;
      RECT 2500 0 18160 5810 ;
    LAYER M8 ;
      RECT 18160 14000 20660 15660 ;
    LAYER M8 ;
      RECT 18160 0 20660 1660 ;
    LAYER M8 ;
      RECT 19000 0 20660 15660 ;
    LAYER M8 ;
      RECT 0 6650 18160 9010 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 9010 6740 13160 ;
    LAYER M8 ;
      RECT 5000 2500 6740 6650 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 9010 9713 13160 ;
    LAYER M8 ;
      RECT 7973 2500 9713 6650 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 9010 12687 13160 ;
    LAYER M8 ;
      RECT 10947 2500 12687 6650 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 9010 15660 13160 ;
    LAYER M8 ;
      RECT 13920 2500 15660 6650 ;
    LAYER M5 ;
      RECT 9730 0 10930 15660 ;
    LAYER M5 ;
      RECT 2500 7230 18160 8430 ;
    LAYER M5 ;
      RECT 11530 9630 12730 15660 ;
    LAYER M5 ;
      RECT 11530 9030 18160 10230 ;
    LAYER M5 ;
      RECT 13330 11430 14530 15660 ;
    LAYER M5 ;
      RECT 13330 10830 18160 12030 ;
    LAYER M5 ;
      RECT 15130 13230 16330 15660 ;
    LAYER M5 ;
      RECT 15130 12630 18160 13830 ;
    LAYER M5 ;
      RECT 16930 15030 18130 15660 ;
    LAYER M5 ;
      RECT 16930 14430 18160 15630 ;
    LAYER M5 ;
      RECT 7930 9630 9130 15660 ;
    LAYER M5 ;
      RECT 2500 9030 9130 10230 ;
    LAYER M5 ;
      RECT 6130 11430 7330 15660 ;
    LAYER M5 ;
      RECT 2500 10830 7330 12030 ;
    LAYER M5 ;
      RECT 4330 13230 5530 15660 ;
    LAYER M5 ;
      RECT 2500 12630 5530 13830 ;
    LAYER M5 ;
      RECT 2530 15030 3730 15660 ;
    LAYER M5 ;
      RECT 2500 14430 3730 15630 ;
    LAYER M5 ;
      RECT 7930 0 9130 6030 ;
    LAYER M5 ;
      RECT 2500 5430 9130 6630 ;
    LAYER M5 ;
      RECT 6130 0 7330 4230 ;
    LAYER M5 ;
      RECT 2500 3630 7330 4830 ;
    LAYER M5 ;
      RECT 4330 0 5530 2430 ;
    LAYER M5 ;
      RECT 2500 1830 5530 3030 ;
    LAYER M5 ;
      RECT 2530 0 3730 630 ;
    LAYER M5 ;
      RECT 2500 30 3730 1230 ;
    LAYER M5 ;
      RECT 11530 0 12730 6030 ;
    LAYER M5 ;
      RECT 11530 5430 18160 6630 ;
    LAYER M5 ;
      RECT 13330 0 14530 4230 ;
    LAYER M5 ;
      RECT 13330 3630 18160 4830 ;
    LAYER M5 ;
      RECT 15130 0 16330 2430 ;
    LAYER M5 ;
      RECT 15130 1830 18160 3030 ;
    LAYER M5 ;
      RECT 16930 0 18130 630 ;
    LAYER M5 ;
      RECT 16930 30 18160 1230 ;
    LAYER M5 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M5 ;
      RECT 2500 0 18160 430 ;
    LAYER M6 ;
      RECT 10630 8730 11830 15660 ;
    LAYER M6 ;
      RECT 10630 8130 18160 9330 ;
    LAYER M6 ;
      RECT 12430 10530 13630 15660 ;
    LAYER M6 ;
      RECT 12430 9930 18160 11130 ;
    LAYER M6 ;
      RECT 14230 12330 15430 15660 ;
    LAYER M6 ;
      RECT 14230 11730 18160 12930 ;
    LAYER M6 ;
      RECT 16030 14130 17230 15660 ;
    LAYER M6 ;
      RECT 16030 13530 18160 14730 ;
    LAYER M6 ;
      RECT 8830 8730 10030 15660 ;
    LAYER M6 ;
      RECT 2500 8130 10030 9330 ;
    LAYER M6 ;
      RECT 7030 10530 8230 15660 ;
    LAYER M6 ;
      RECT 2500 9930 8230 11130 ;
    LAYER M6 ;
      RECT 5230 12330 6430 15660 ;
    LAYER M6 ;
      RECT 2500 11730 6430 12930 ;
    LAYER M6 ;
      RECT 3430 14130 4630 15660 ;
    LAYER M6 ;
      RECT 2500 13530 4630 14730 ;
    LAYER M6 ;
      RECT 8830 0 10030 6930 ;
    LAYER M6 ;
      RECT 2500 6330 10030 7530 ;
    LAYER M6 ;
      RECT 7030 0 8230 5130 ;
    LAYER M6 ;
      RECT 2500 4530 8230 5730 ;
    LAYER M6 ;
      RECT 5230 0 6430 3330 ;
    LAYER M6 ;
      RECT 2500 2730 6430 3930 ;
    LAYER M6 ;
      RECT 3430 0 4630 1530 ;
    LAYER M6 ;
      RECT 2500 930 4630 2130 ;
    LAYER M6 ;
      RECT 10630 0 11830 6930 ;
    LAYER M6 ;
      RECT 10630 6330 18160 7530 ;
    LAYER M6 ;
      RECT 12430 0 13630 5130 ;
    LAYER M6 ;
      RECT 12430 4530 18160 5730 ;
    LAYER M6 ;
      RECT 14230 0 15430 3330 ;
    LAYER M6 ;
      RECT 14230 2730 18160 3930 ;
    LAYER M6 ;
      RECT 16030 0 17230 1530 ;
    LAYER M6 ;
      RECT 16030 930 18160 2130 ;
    LAYER M6 ;
      RECT 2500 15230 18160 15660 ;
    LAYER M6 ;
      RECT 2500 0 18160 430 ;
  END
END xc3_1

MACRO xR3_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR3_1 0 0 ;
  SIZE 37070 BY 9510 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 9290 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 36750 220 36840 9290 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 36870 9290 ;
    LAYER RPO ;
      RECT 540 0 36530 9510 ;
    LAYER M1 ;
      RECT 230 235 320 9275 ;
    LAYER M1 ;
      RECT 36750 235 36840 9275 ;
    LAYER RH ;
      RECT 0 20 37070 9490 ;
  END
END xR3_1

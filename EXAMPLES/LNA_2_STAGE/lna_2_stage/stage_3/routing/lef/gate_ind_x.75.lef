MACRO gate_ind_x.75
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gate_ind_x.75 0 0 ;
  SIZE 122939 BY 125064 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 116939 64690 122939 70690 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 54374 0 60374 6000 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 104064 62690 114064 72690 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 75439 64690 98439 70690 ;
    LAYER M8 ;
      RECT 0 10316 114748 125064 ;
    LAYER M9 ;
      RECT 92439 64690 122939 70690 ;
    LAYER M9 ;
      RECT 24809 33000 89939 102380 ;
    LAYER M9 ;
      RECT 54374 0 60374 39000 ;
    LAYER M9 ;
      RECT 0 10316 114748 125064 ;
    LAYER M1 ;
      RECT 0 10316 114748 125064 ;
    LAYER M2 ;
      RECT 0 10316 114748 125064 ;
    LAYER M3 ;
      RECT 0 10316 114748 125064 ;
    LAYER M4 ;
      RECT 0 10316 114748 125064 ;
    LAYER M5 ;
      RECT 0 10316 114748 125064 ;
    LAYER M6 ;
      RECT 0 10316 114748 125064 ;
    LAYER M7 ;
      RECT 0 10316 114748 125064 ;
  END
END gate_ind_x.75

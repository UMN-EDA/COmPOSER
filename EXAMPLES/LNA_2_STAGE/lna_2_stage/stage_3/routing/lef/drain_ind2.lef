MACRO drain_ind2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN drain_ind2 0 0 ;
  SIZE 90000 BY 43500 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 3500 23500 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 86500 20000 90000 23500 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 90000 23500 ;
    LAYER M1 ;
      RECT 3500 0 86500 43500 ;
  END
END drain_ind2

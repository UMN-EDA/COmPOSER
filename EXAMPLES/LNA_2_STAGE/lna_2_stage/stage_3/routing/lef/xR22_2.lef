MACRO xR22_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR22_2 0 0 ;
  SIZE 6650 BY 8860 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 8640 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 6330 220 6420 8640 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 6450 8640 ;
    LAYER RPO ;
      RECT 540 0 6110 8860 ;
    LAYER M1 ;
      RECT 230 235 320 8625 ;
    LAYER M1 ;
      RECT 6330 235 6420 8625 ;
    LAYER RH ;
      RECT 0 20 6650 8840 ;
  END
END xR22_2

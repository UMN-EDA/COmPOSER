MACRO cas_mos1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN cas_mos1 0 0 ;
  SIZE 7185 BY 8530 ;
  PIN SS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M7 ;
        RECT 0 4850 300 5890 ;
    END
  END SS
  PIN GG
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1365 7530 6185 8530 ;
    END
  END GG
  PIN DD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1165 0 6385 1000 ;
    END
  END DD
  PIN G2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 6685 2880 7185 4480 ;
    END
  END G2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 700 4368 910 4578 ;
    END
  END GND
  OBS
    LAYER M6 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M6 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M6 ;
      RECT 1365 6530 6185 6890 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M6 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M6 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M6 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M6 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M6 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M6 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M6 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M6 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M6 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M6 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M6 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M6 ;
      RECT 1165 1470 6385 2000 ;
    LAYER M1 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M1 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M1 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M1 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M1 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M1 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M1 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M1 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M1 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M1 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M1 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M1 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M1 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M1 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M1 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M1 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M1 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M1 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M1 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M1 ;
      RECT 1365 5990 6185 6170 ;
    LAYER M1 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M1 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M1 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M1 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M1 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M1 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M1 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M1 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M1 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M1 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M1 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M1 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M1 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M1 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M1 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M1 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M1 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M1 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M1 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M1 ;
      RECT 1365 4300 6185 4480 ;
    LAYER M1 ;
      RECT 1365 2880 6185 3060 ;
    LAYER M1 ;
      RECT 700 2510 6850 6540 ;
    LAYER M2 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M2 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M2 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M2 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M2 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M2 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M2 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M2 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M2 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M2 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M2 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M2 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M2 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M2 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M2 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M2 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M2 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M2 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M2 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M2 ;
      RECT 1365 5990 6185 6170 ;
    LAYER M2 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M2 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M2 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M2 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M2 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M2 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M2 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M2 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M2 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M2 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M2 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M2 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M2 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M2 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M2 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M2 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M2 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M2 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M2 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M2 ;
      RECT 1365 4300 6185 4480 ;
    LAYER M2 ;
      RECT 1365 2880 6185 3060 ;
    LAYER M3 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M3 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M3 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M3 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M3 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M3 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M3 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M3 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M3 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M3 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M3 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M3 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M3 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M3 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M3 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M3 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M3 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M3 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M3 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M3 ;
      RECT 1365 5990 6185 6170 ;
    LAYER M3 ;
      RECT 1365 6170 6185 6350 ;
    LAYER M3 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M3 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M3 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M3 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M3 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M3 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M3 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M3 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M3 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M3 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M3 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M3 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M3 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M3 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M3 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M3 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M3 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M3 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M3 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M3 ;
      RECT 1365 4300 6185 4480 ;
    LAYER M3 ;
      RECT 6185 4300 6685 4480 ;
    LAYER M3 ;
      RECT 1365 2880 6185 3060 ;
    LAYER M3 ;
      RECT 6185 2880 6685 3060 ;
    LAYER M3 ;
      RECT 6685 2880 7185 4480 ;
    LAYER M4 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M4 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M4 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M4 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M4 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M4 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M4 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M4 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M4 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M4 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M4 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M4 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M4 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M4 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M4 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M4 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M4 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M4 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M4 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M4 ;
      RECT 1365 6170 6185 6530 ;
    LAYER M4 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M4 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M4 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M4 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M4 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M4 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M4 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M4 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M4 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M4 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M4 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M4 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M4 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M4 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M4 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M4 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M4 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M4 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M4 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M5 ;
      RECT 1165 4850 1345 5890 ;
    LAYER M5 ;
      RECT 6205 4850 6385 5890 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4200 1625 4850 ;
    LAYER M5 ;
      RECT 1445 4850 1625 5890 ;
    LAYER M5 ;
      RECT 1725 4850 1905 5890 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4200 2185 4850 ;
    LAYER M5 ;
      RECT 2005 4850 2185 5890 ;
    LAYER M5 ;
      RECT 2285 4850 2465 5890 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4200 2745 4850 ;
    LAYER M5 ;
      RECT 2565 4850 2745 5890 ;
    LAYER M5 ;
      RECT 2845 4850 3025 5890 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4200 3305 4850 ;
    LAYER M5 ;
      RECT 3125 4850 3305 5890 ;
    LAYER M5 ;
      RECT 3405 4850 3585 5890 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4200 3865 4850 ;
    LAYER M5 ;
      RECT 3685 4850 3865 5890 ;
    LAYER M5 ;
      RECT 3965 4850 4145 5890 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4200 4425 4850 ;
    LAYER M5 ;
      RECT 4245 4850 4425 5890 ;
    LAYER M5 ;
      RECT 4525 4850 4705 5890 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4200 4985 4850 ;
    LAYER M5 ;
      RECT 4805 4850 4985 5890 ;
    LAYER M5 ;
      RECT 5085 4850 5265 5890 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4200 5545 4850 ;
    LAYER M5 ;
      RECT 5365 4850 5545 5890 ;
    LAYER M5 ;
      RECT 5645 4850 5825 5890 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4200 6105 4850 ;
    LAYER M5 ;
      RECT 5925 4850 6105 5890 ;
    LAYER M5 ;
      RECT 1365 6350 6185 6710 ;
    LAYER M5 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M5 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M5 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M5 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M5 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M5 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M5 ;
      RECT 1445 3160 1625 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M5 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M5 ;
      RECT 2005 3160 2185 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M5 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M5 ;
      RECT 2565 3160 2745 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M5 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M5 ;
      RECT 3125 3160 3305 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M5 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M5 ;
      RECT 3685 3160 3865 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M5 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M5 ;
      RECT 4245 3160 4425 4200 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M5 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M5 ;
      RECT 4805 3160 4985 4200 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M5 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M5 ;
      RECT 5365 3160 5545 4200 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M5 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M5 ;
      RECT 5925 3160 6105 4200 ;
    LAYER M5 ;
      RECT 1165 1470 6385 2000 ;
    LAYER Poly ;
      RECT 1365 4730 1425 5970 ;
    LAYER Poly ;
      RECT 1645 4730 1705 5970 ;
    LAYER Poly ;
      RECT 1925 4730 1985 5970 ;
    LAYER Poly ;
      RECT 2205 4730 2265 5970 ;
    LAYER Poly ;
      RECT 2485 4730 2545 5970 ;
    LAYER Poly ;
      RECT 2765 4730 2825 5970 ;
    LAYER Poly ;
      RECT 3045 4730 3105 5970 ;
    LAYER Poly ;
      RECT 3325 4730 3385 5970 ;
    LAYER Poly ;
      RECT 3605 4730 3665 5970 ;
    LAYER Poly ;
      RECT 3885 4730 3945 5970 ;
    LAYER Poly ;
      RECT 4165 4730 4225 5970 ;
    LAYER Poly ;
      RECT 4445 4730 4505 5970 ;
    LAYER Poly ;
      RECT 4725 4730 4785 5970 ;
    LAYER Poly ;
      RECT 5005 4730 5065 5970 ;
    LAYER Poly ;
      RECT 5285 4730 5345 5970 ;
    LAYER Poly ;
      RECT 5565 4730 5625 5970 ;
    LAYER Poly ;
      RECT 5845 4730 5905 5970 ;
    LAYER Poly ;
      RECT 6125 4730 6185 5970 ;
    LAYER Poly ;
      RECT 1365 5970 6185 6180 ;
    LAYER Poly ;
      RECT 1365 3080 1425 4280 ;
    LAYER Poly ;
      RECT 1645 3080 1705 4280 ;
    LAYER Poly ;
      RECT 1925 3080 1985 4280 ;
    LAYER Poly ;
      RECT 2205 3080 2265 4280 ;
    LAYER Poly ;
      RECT 2485 3080 2545 4280 ;
    LAYER Poly ;
      RECT 2765 3080 2825 4280 ;
    LAYER Poly ;
      RECT 3045 3080 3105 4280 ;
    LAYER Poly ;
      RECT 3325 3080 3385 4280 ;
    LAYER Poly ;
      RECT 3605 3080 3665 4280 ;
    LAYER Poly ;
      RECT 3885 3080 3945 4280 ;
    LAYER Poly ;
      RECT 4165 3080 4225 4280 ;
    LAYER Poly ;
      RECT 4445 3080 4505 4280 ;
    LAYER Poly ;
      RECT 4725 3080 4785 4280 ;
    LAYER Poly ;
      RECT 5005 3080 5065 4280 ;
    LAYER Poly ;
      RECT 5285 3080 5345 4280 ;
    LAYER Poly ;
      RECT 5565 3080 5625 4280 ;
    LAYER Poly ;
      RECT 5845 3080 5905 4280 ;
    LAYER Poly ;
      RECT 6125 3080 6185 4280 ;
    LAYER Poly ;
      RECT 1365 4280 6185 4490 ;
    LAYER Poly ;
      RECT 1365 2870 6185 3080 ;
    LAYER M7 ;
      RECT 0 4850 6385 5890 ;
    LAYER M7 ;
      RECT 1365 6710 6185 7410 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 1165 2510 1345 3160 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 1165 3160 1345 4200 ;
    LAYER M7 ;
      RECT 6205 3160 6385 4200 ;
    LAYER M7 ;
      RECT 1165 2000 1345 3160 ;
    LAYER M7 ;
      RECT 6205 2000 6385 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 1725 3160 1905 4200 ;
    LAYER M7 ;
      RECT 1725 2000 1905 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2285 3160 2465 4200 ;
    LAYER M7 ;
      RECT 2285 2000 2465 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 2845 3160 3025 4200 ;
    LAYER M7 ;
      RECT 2845 2000 3025 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3405 3160 3585 4200 ;
    LAYER M7 ;
      RECT 3405 2000 3585 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 3965 3160 4145 4200 ;
    LAYER M7 ;
      RECT 3965 2000 4145 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 4525 3160 4705 4200 ;
    LAYER M7 ;
      RECT 4525 2000 4705 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5085 3160 5265 4200 ;
    LAYER M7 ;
      RECT 5085 2000 5265 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 5645 3160 5825 4200 ;
    LAYER M7 ;
      RECT 5645 2000 5825 3160 ;
    LAYER M7 ;
      RECT 1165 1470 6385 2000 ;
    LAYER M8 ;
      RECT 1365 6710 6185 7750 ;
    LAYER M8 ;
      RECT 1165 760 6385 2000 ;
    LAYER M9 ;
      RECT 1365 6530 6185 8530 ;
    LAYER M9 ;
      RECT 1165 0 6385 2000 ;
  END
END cas_mos1

MACRO xR0_0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR0_0 0 0 ;
  SIZE 32300 BY 9880 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 220 320 9660 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 31980 220 32070 9660 ;
    END
  END MINUS
  OBS
    LAYER Poly ;
      RECT 200 220 32100 9660 ;
    LAYER RPO ;
      RECT 540 0 31760 9880 ;
    LAYER M1 ;
      RECT 230 235 320 9645 ;
    LAYER M1 ;
      RECT 31980 235 32070 9645 ;
    LAYER RH ;
      RECT 0 20 32300 9860 ;
  END
END xR0_0

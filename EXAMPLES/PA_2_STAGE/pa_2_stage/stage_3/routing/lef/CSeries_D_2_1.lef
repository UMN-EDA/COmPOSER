MACRO CSeries_D_2_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CSeries_D_2_1 0 0 ;
  SIZE 7810 BY 9250 ;
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 100 840 9150 ;
    END
  END MINUS
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 6530 3895 7810 5355 ;
    END
  END PLUS
  OBS
    LAYER M8 ;
      RECT 0 7690 6130 9150 ;
    LAYER M8 ;
      RECT 0 100 6130 1560 ;
    LAYER M8 ;
      RECT 0 1560 840 7690 ;
    LAYER M8 ;
      RECT 1680 3895 7810 5355 ;
    LAYER M8 ;
      RECT 1820 2540 3280 6710 ;
    LAYER M8 ;
      RECT 4530 2540 5990 6710 ;
  END
END CSeries_D_2_1

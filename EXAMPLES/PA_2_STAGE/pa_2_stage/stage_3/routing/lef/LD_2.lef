MACRO LD_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_2 0 0 ;
  SIZE 80000 BY 42000 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 2000 22000 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 78000 20000 80000 22000 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 80000 22000 ;
    LAYER M1 ;
      RECT 2000 0 78000 42000 ;
  END
END LD_2

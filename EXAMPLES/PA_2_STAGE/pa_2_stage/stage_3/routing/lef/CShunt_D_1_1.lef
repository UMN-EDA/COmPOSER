MACRO CShunt_D_1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CShunt_D_1_1 0 0 ;
  SIZE 16840 BY 11840 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6818 11410 10022 11840 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6818 0 10022 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 4740 1660 7100 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 15180 1760 16840 10080 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 7940 14340 11840 ;
    LAYER M8 ;
      RECT 2500 0 14340 3900 ;
    LAYER M8 ;
      RECT 14340 10180 16840 11840 ;
    LAYER M8 ;
      RECT 14340 0 16840 1660 ;
    LAYER M8 ;
      RECT 15180 0 16840 11840 ;
    LAYER M8 ;
      RECT 0 4740 14340 7100 ;
    LAYER M8 ;
      RECT 5000 7100 6740 9340 ;
    LAYER M8 ;
      RECT 5000 7100 6740 9340 ;
    LAYER M8 ;
      RECT 5000 2500 6740 4740 ;
    LAYER M8 ;
      RECT 10100 7100 11840 9340 ;
    LAYER M8 ;
      RECT 10100 7100 11840 9340 ;
    LAYER M8 ;
      RECT 10100 2500 11840 4740 ;
    LAYER M5 ;
      RECT 7820 0 9020 11840 ;
    LAYER M5 ;
      RECT 2500 5320 14340 6520 ;
    LAYER M5 ;
      RECT 9620 7720 10820 11840 ;
    LAYER M5 ;
      RECT 9620 7120 14340 8320 ;
    LAYER M5 ;
      RECT 11420 9520 12620 11840 ;
    LAYER M5 ;
      RECT 11420 8920 14340 10120 ;
    LAYER M5 ;
      RECT 13220 11320 14340 11840 ;
    LAYER M5 ;
      RECT 13220 10720 14340 11840 ;
    LAYER M5 ;
      RECT 6020 7720 7220 11840 ;
    LAYER M5 ;
      RECT 2500 7120 7220 8320 ;
    LAYER M5 ;
      RECT 4220 9520 5420 11840 ;
    LAYER M5 ;
      RECT 2500 8920 5420 10120 ;
    LAYER M5 ;
      RECT 2500 11320 3620 11840 ;
    LAYER M5 ;
      RECT 2500 10720 3620 11840 ;
    LAYER M5 ;
      RECT 6020 0 7220 4120 ;
    LAYER M5 ;
      RECT 2500 3520 7220 4720 ;
    LAYER M5 ;
      RECT 4220 0 5420 2320 ;
    LAYER M5 ;
      RECT 2500 1720 5420 2920 ;
    LAYER M5 ;
      RECT 2500 0 3620 520 ;
    LAYER M5 ;
      RECT 2500 0 3620 1120 ;
    LAYER M5 ;
      RECT 9620 0 10820 4120 ;
    LAYER M5 ;
      RECT 9620 3520 14340 4720 ;
    LAYER M5 ;
      RECT 11420 0 12620 2320 ;
    LAYER M5 ;
      RECT 11420 1720 14340 2920 ;
    LAYER M5 ;
      RECT 13220 0 14340 520 ;
    LAYER M5 ;
      RECT 13220 0 14340 1120 ;
    LAYER M5 ;
      RECT 2500 11410 14340 11840 ;
    LAYER M5 ;
      RECT 2500 0 14340 430 ;
    LAYER M6 ;
      RECT 8720 6820 9920 11840 ;
    LAYER M6 ;
      RECT 8720 6220 14340 7420 ;
    LAYER M6 ;
      RECT 10520 8620 11720 11840 ;
    LAYER M6 ;
      RECT 10520 8020 14340 9220 ;
    LAYER M6 ;
      RECT 12320 10420 13520 11840 ;
    LAYER M6 ;
      RECT 12320 9820 14340 11020 ;
    LAYER M6 ;
      RECT 6920 6820 8120 11840 ;
    LAYER M6 ;
      RECT 2500 6220 8120 7420 ;
    LAYER M6 ;
      RECT 5120 8620 6320 11840 ;
    LAYER M6 ;
      RECT 2500 8020 6320 9220 ;
    LAYER M6 ;
      RECT 3320 10420 4520 11840 ;
    LAYER M6 ;
      RECT 2500 9820 4520 11020 ;
    LAYER M6 ;
      RECT 6920 0 8120 5020 ;
    LAYER M6 ;
      RECT 2500 4420 8120 5620 ;
    LAYER M6 ;
      RECT 5120 0 6320 3220 ;
    LAYER M6 ;
      RECT 2500 2620 6320 3820 ;
    LAYER M6 ;
      RECT 3320 0 4520 1420 ;
    LAYER M6 ;
      RECT 2500 820 4520 2020 ;
    LAYER M6 ;
      RECT 8720 0 9920 5020 ;
    LAYER M6 ;
      RECT 8720 4420 14340 5620 ;
    LAYER M6 ;
      RECT 10520 0 11720 3220 ;
    LAYER M6 ;
      RECT 10520 2620 14340 3820 ;
    LAYER M6 ;
      RECT 12320 0 13520 1420 ;
    LAYER M6 ;
      RECT 12320 820 14340 2020 ;
    LAYER M6 ;
      RECT 2500 11410 14340 11840 ;
    LAYER M6 ;
      RECT 2500 0 14340 430 ;
  END
END CShunt_D_1_1

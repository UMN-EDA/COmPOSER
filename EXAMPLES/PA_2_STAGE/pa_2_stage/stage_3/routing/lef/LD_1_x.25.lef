MACRO LD_1_x.25
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_1_x.25 0 0 ;
  SIZE 105921 BY 107671 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 100921 47001 105921 52001 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 47001 102671 52001 107671 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 87671 44501 97671 54501 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 61421 47001 80421 52001 ;
    LAYER M8 ;
      RECT 0 0 99002 99002 ;
    LAYER M9 ;
      RECT 75421 47001 105921 52001 ;
    LAYER M9 ;
      RECT 25581 23831 73421 75171 ;
    LAYER M9 ;
      RECT 47001 70171 52001 107671 ;
    LAYER M9 ;
      RECT 0 0 99002 99002 ;
    LAYER M1 ;
      RECT 0 0 99002 99002 ;
    LAYER M2 ;
      RECT 0 0 99002 99002 ;
    LAYER M3 ;
      RECT 0 0 99002 99002 ;
    LAYER M4 ;
      RECT 0 0 99002 99002 ;
    LAYER M5 ;
      RECT 0 0 99002 99002 ;
    LAYER M6 ;
      RECT 0 0 99002 99002 ;
    LAYER M7 ;
      RECT 0 0 99002 99002 ;
  END
END LD_1_x.25

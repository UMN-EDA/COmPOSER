MACRO LIn_1_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_1_x.1 0 0 ;
  SIZE 103423 BY 99726 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 97423 51423 103423 57423 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 97423 42303 103423 48303 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 88423 44863 98423 54863 ;
    END
  END GND
  OBS
    LAYER M9 ;
      RECT 23303 23303 76423 76423 ;
    LAYER M9 ;
      RECT 70423 51423 103423 57423 ;
    LAYER M9 ;
      RECT 70423 42303 103423 48303 ;
    LAYER M9 ;
      RECT 0 0 99726 99726 ;
    LAYER M1 ;
      RECT 0 0 99726 99726 ;
    LAYER M2 ;
      RECT 0 0 99726 99726 ;
    LAYER M3 ;
      RECT 0 0 99726 99726 ;
    LAYER M4 ;
      RECT 0 0 99726 99726 ;
    LAYER M5 ;
      RECT 0 0 99726 99726 ;
    LAYER M6 ;
      RECT 0 0 99726 99726 ;
    LAYER M7 ;
      RECT 0 0 99726 99726 ;
    LAYER M8 ;
      RECT 0 0 99726 99726 ;
  END
END LIn_1_x.1

MACRO LIn_2
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LIn_2 0 0 ;
  SIZE 90000 BY 48000 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 20000 8000 28000 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 82000 20000 90000 28000 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 0 20000 90000 28000 ;
    LAYER M1 ;
      RECT 8000 0 82000 48000 ;
  END
END LIn_2

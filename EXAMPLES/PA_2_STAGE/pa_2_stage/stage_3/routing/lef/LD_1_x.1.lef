MACRO LD_1_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN LD_1_x.1 0 0 ;
  SIZE 101201 BY 97592 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 97701 50356 101201 53856 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 97701 43736 101201 47236 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 86201 43796 96201 53796 ;
    END
  END GND
  OBS
    LAYER M9 ;
      RECT 24641 24641 72951 72951 ;
    LAYER M9 ;
      RECT 69451 50356 101201 53856 ;
    LAYER M9 ;
      RECT 69451 43736 101201 47236 ;
    LAYER M9 ;
      RECT 0 0 97592 97592 ;
    LAYER M1 ;
      RECT 0 0 97592 97592 ;
    LAYER M2 ;
      RECT 0 0 97592 97592 ;
    LAYER M3 ;
      RECT 0 0 97592 97592 ;
    LAYER M4 ;
      RECT 0 0 97592 97592 ;
    LAYER M5 ;
      RECT 0 0 97592 97592 ;
    LAYER M6 ;
      RECT 0 0 97592 97592 ;
    LAYER M7 ;
      RECT 0 0 97592 97592 ;
    LAYER M8 ;
      RECT 0 0 97592 97592 ;
  END
END LD_1_x.1
